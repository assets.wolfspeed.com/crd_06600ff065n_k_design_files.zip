# Allegro board HD_6k6W_OBC_MAIN_BOARD-v3_pcb_layout.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
N17603041 on ART05 (solid shape): 132.05,80.96 132.05,66.12 130.84,64.9 126.1,64.9 125.18,65.82 125.18,66.83 125.17,66.86 125.17,69.14 123.73,70.58 113.52,70.58 112.29,69.34 112.29,65.94 111.45,65.11 106.95,65.11 106.03,66.03 106.03,75.44 106.96,76.37 117.94,76.37 120.31,78.74 120.31,84.18 121.63,85.5 127.51,85.5
N165538091 on TOP (solid shape): 139.49,150.42 139.58,150.36 139.56,150.25 140.64,147.64 141.72,150.25 141.7,150.36 141.79,150.42 144.47,150.42 145.17,149.72 145.17,142 145.16,141.99 145.16,141.84 143.7,140.37 142.23,140.37 141.28,143.09 140.32,140.37 138.96,140.37 138.14,141.2 138.14,149.63 138.93,150.42
N165538091 on ART05 (solid shape): 145.17,149.72 145.17,142 144.11,140.94 138.4,140.94 138.14,141.2 138.14,149.63 138.93,150.42 144.47,150.42
N165801940 on BOTTOM (solid shape): 130.25,167.34 130.25,164.38 130.07,164.21 128.25,164.21 128.09,164.38 128.09,167.28 128.44,167.64 129.94,167.64

## Text on the board
BOTTOM: ARTWORK BOTTOM
Board Geometry/Soldermask Bottom: SOLDERMASK BOTTOM
Package Geometry/Pastemask Bottom: PASTEMASK BOTTOM
Ref Des/Silkscreen Bottom: SILKSCREEN BOTTOM
TOP: ARTWORK TOP
Board Geometry/Soldermask Top: SOLDERMASK TOP
Package Geometry/Pastemask Top: PASTEMASK TOP
Ref Des/Silkscreen Top: T | M | CRD06600FF065N Main Board | REV 3 1919 | SILKSCREEN TOP
ART02: ARTWORK LAYER02
ART03: ARTWORK LAYER03
GND04: ARTWORK LAYER04
ART05: ARTWORK LAYER05
DIMENSION: Board Cut Out | FAB DRAWING
ASSEMBLY_TOP: PRIMARY SIDE
ASSEMBLY_BOTTOM: SECONDARY SIDE
User.24: FIGURE | SIZE | 12.0 | 32.0 | 39.0 | 40.0 | 47.0 | 49.0 | 51.0 | 59.0 | 59.06 | 70.0 | 87.0 | 122.0 | 158.0 | 79.0x39.0 | 157.0x98.0 | 177.17x102.36 | 217.0x138.0 | 222.0x98.0 | 236.0x138.0 | 236.22x173.22 | DRILL CHART: TOP to BOTTOM | ALL UNITS ARE IN MILS | TOLERANCE | +0.0/-0.0 | +3.0/-3.0 | +2.99/-2.99 | PLATED | NON-PLATED | QTY | 478 | 4 | 64 | 60 | 6 | 8 | 28 | 42 | 2 | 1 | 3
