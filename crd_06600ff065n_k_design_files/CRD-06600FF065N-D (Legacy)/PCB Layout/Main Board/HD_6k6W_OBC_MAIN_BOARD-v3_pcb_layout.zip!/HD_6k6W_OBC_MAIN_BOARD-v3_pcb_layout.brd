# Allegro board HD_6k6W_OBC_MAIN_BOARD-v3_pcb_layout.brd (continued)
## Nets (continued)
N17880973: D59.1(ANODE) R566.2
N165538091: RV1.1 RV2.2
N165801940: D1.1(A) R4.1

Pads without a net: CON2 2; J3 1 6 8 13; J4 5 9 12; J7 3 4 7 8; J8 3; NOREF#6 1; NOREF#8 1; NOREF#13 1; NOREF#14 1; NOREF#15 1; NOREF#16 1; T1 1 4 8 10 11; U5 7 12 13; U10 6 7 10 11; U35 1 4

## Via types
v1: diameter 0.61, hole 0.305, TOP to BOTTOM, 478 vias

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
+5V_A: length 120.5
  TOP w0.508: v1(107.52,135.84) 106.68,136.68 R596.1 108.34,137.04 C610.2
  ART05 w0.508: v1(85.34,140.34) 87.89,137.79 103.53,137.79 105.49,135.84 v1(107.52,135.84) 107.6,135.92 107.6,136.83 104.78,139.65 v1(104.78,142.24) 104.78,143.72 121.83,160.77 132.39,160.77 134.39,162.78 134.39,171.54 138.99,176.13 154.7,176.13 v1(156.21,174.62)
  BOTTOM w0.508: v1(107.52,135.84) 107.52,136.65 107.01,137.16 R242.2 ; v1(156.21,174.62) 156.21,171.45 157.6,170.06 C596.2 159.26,169.54 R573.1 ; R246.1 C611.1 104.65,142.12 v1(104.78,142.24)
-3V_PSW1: length 203.2
  ART05 w0.508: v1(205.74,71.75) 205.74,100.61 190.78,115.57 173.35,115.57 169.19,119.74 132.76,119.74 129.83,122.66 125.36,122.66 v1(124.23,121.54) 122.95,120.25 119.55,120.25 118.37,121.43 v1(118.37,121.46) 113.53,116.61 84.05,116.61 77.98,122.68 v1(76.58,122.68)
  BOTTOM w0.508: v1(118.37,121.46) 117.89,121.95 116.87,121.95 C45.2 115.63,121.97 115.32,121.66 115.31,121.66 114.44,120.79 ZD14.1 ; 70.37,116.34 C37.2 66.76,116.34 65.16,117.94 D47.1 64.88,119.1 64.26,119.1 63.78,118.62 C525.2 ; 70.37,116.34 70.48,116.34 71.24,117.09 73.03,117.09 73.16,116.95 75.74,116.95 76.2,117.42 U5.9 76.2,120.02 76.58,120.39 C38.2 76.58,122.3 v1(76.58,122.68) ; 70.37,116.34 ZD13.1 ; U106.8 v1(124.23,121.54) 124.08,121.69 C46.2
-3V_PSW2: length 54.6
  ART03 w0.508: v1(192.41,88.9) 191.18,90.12 191.18,97.36 193.43,99.6 193.43,103.24 177.93,118.75 v1(168.28,118.75)
  BOTTOM w0.508: v1(168.28,118.75) U104.8 168.28,121.45 166.63,123.1 C41.2 166.63,124.08 C499.2
-3V_PSW3: length 43.6
  ART05 w0.508: v1(87,117.47) 85.72,117.47 v1(80.13,123.07) 80.26,123.19 80.26,128.02 73.66,134.62 v1(63.5,134.62)
  BOTTOM w0.508: D48.1 87.12,118.75 C524.2 v1(87,117.47) ; U5.14 82.55,119.42 82.16,119.82 81.52,119.82 81.02,120.31 C33.2 81.28,121.54 C496.2 v1(80.13,123.07)
-3V_PSW4: length 84.2
  ART03 w0.508: v1(131.82,46.31) 134.55,43.58 171.6,43.58 v1(173.48,45.47)
  ART05 w0.381: v1(173.48,45.47) 174.24,45.47 177.29,42.42 177.29,31.95 U21.5
  BOTTOM w0.508: U21.5 169.17,24.13 ; U107.8 127,44.78 127.51,44.27 128.22,44.27 128.65,44.71 C549.2 130.61,44.71 130.99,45.09 C547.2 131.96,46.17 v1(131.82,46.31) ; v1(173.48,45.47) 172.72,44.7 C561.2 171.32,44.57 C563.2 169.67,44.07 169.49,43.89 168.86,43.89 168.28,44.48 U109.8
-3V_PSW5: length 38.8
  ART05 w0.508: v1(110.49,46.35) 110.49,39.36 123.81,26.04 U19.5
  BOTTOM w0.508: v1(110.49,46.35) C537.2 109.09,44.96 C542.2 107.44,44.45 107.26,44.27 106.63,44.27 106.05,44.86 U108.8
-3V_PSW7: length 30.3
  ART05 w0.381: v1(154.05,44.45) 152.91,43.31 152.91,42.42 145.7,35.21 145.7,28.1 U20.5
  BOTTOM w0.508: v1(154.05,44.45) 153.92,44.32 C552.2 151.38,44.32 C556.2 150.7,43.64 148.92,43.64 148.34,44.22 U110.8
-3V_PSW9: length 101.5
  ART02 w0.508: U22.5 84.89,13.97 55.24,13.97 51.06,18.15 25.06,18.15 19.95,23.26 19.95,40.77 v1(25.4,46.22)
  BOTTOM w0.508: v1(25.4,46.22) C566.2 24,44.96 C570.2 22.35,44.45 22.17,44.27 21.54,44.27 20.95,44.86 U112.8
-3V_PSW10: length 103.3
  ART05 w0.508: v1(46.45,46) 48.37,46 50.67,43.71 87.54,43.71 v1(89.05,45.21) 90.34,43.92 90.74,43.92 99.64,35.02 99.64,30.17 108.02,21.8 110.78,21.8 112.56,20.01 112.56,16.23 U24.5
  BOTTOM w0.508: v1(46.45,46) 46.23,45.78 C575.2 44.45,44.45 C577.2 43.31,44.45 43.13,44.27 42.5,44.27 41.91,44.86 U111.8 ; v1(89.05,45.21) 87.77,45.21 87.51,44.94 C589.2 86.55,44.2 86.3,44.45 C591.2 83.06,44.45 82.55,44.96 U113.8
-3V_PSW11: length 85.4
  ART02 w0.508: U23.5 96.22,14.71 96.22,16.62 96.75,17.15 98.24,17.15 99.05,17.96 99.05,18.77 93.63,24.19 93.63,52.67 91.19,55.1 74.07,55.1 71.22,52.25 71.22,48.36 69.22,46.35 v1(66.04,46.35)
  BOTTOM w0.508: v1(66.04,46.35) C580.2 64.64,44.96 C584.2 62.99,44.45 62.81,44.27 62.18,44.27 61.59,44.86 U114.8
AGND: length 563.3
  TOP w0.508: C101.2 108.24,27.82 107.69,28.36 v1(107.69,28.44) 107.19,27.94 C102.1 ; U10.8 v1(100.97,38.1)
  ART02 w0.508: J3.3 218.43,71.75 ; J5.6 218.43,42.55 ; 159.45,7.62 J7.9 161.35,9.51 ; 166.43,3.19 J7.6 ; 214,67.32 214,69.22 212.1,69.22 ; 212.1,71.75 214,71.75 ; J5.8 218.43,40.01 ; J3.21 218.43,94.61
  ART02 w1.016: 167.58,16.51 U21.2 ; U21.2 169.48,18.4 ; U21.2 171.37,16.51 ; U19.2 132,18.41 ; U19.2 128.21,18.41 ; U19.2 130.11,20.31 ; U20.2 148.39,19.67 ; U20.2 150.29,17.78 ; U20.2 146.5,17.78 ; 205.23,16.36 C594.2 ; C594.2 208.79,16.36 ; C594.2 207.01,18.13 ; C594.2 207.01,14.58
  ART03 w1.016: U15.2 201.73,65.27 ; U15.2 202.87,64.14 ; U15.2 200.6,64.14 ; 200.6,85.09 U17.2 ; U17.2 202.87,85.09 ; U17.2 201.73,86.22 ; J3.21 217.67,94.61
  GND04 w0.508: 166.43,3.19 J7.6 ; J7.9 161.35,9.51
  GND04 w1.016: 150.29,18.41 148.39,18.41 ; 148.39,18.41 146.5,18.41 ; 148.39,18.41 148.39,20.31 ; 205.23,16.36 C594.2 207.01,18.13 ; 167.58,16.51 U21.2 ; U21.2 171.37,16.51 ; U21.2 169.48,18.4 ; 128.21,18.41 U19.2 ; U19.2 130.11,20.31 ; U19.2 132,18.41
  ART05 w0.254: 216.79,40.01 218.97,37.82 218.97,31.55 v1(217.34,29.92)
  ART05 w0.508: v1(211.89,38.94) 210.82,37.87 v1(210.82,33.02) 209.65,31.85 209.65,29.71 200.21,20.26 v1(189.87,20.26) 181.67,20.26 v1(181.61,20.32) 177.42,16.13 v1(175.9,16.13) 169.86,16.13 U21.2 166.03,16.51 164.01,14.49 151.69,14.49 U20.2 147.32,17.78 144.03,14.49 128.18,14.49 125.47,17.2 125.47,19.41 111.76,33.12 v1(111.76,34.67) 109.86,34.67 v1(108.58,35.94) 106.74,34.1 106.74,29.39 v1(107.69,28.44) 113.95,22.18 113.95,18.7 122.48,10.17 200.83,10.17 C594.2 207.01,19.68 v1(207.65,20.32) 214.25,26.92 215.73,26.92 217.34,28.54 v1(217.34,29.92) ; v1(218.43,51.29) 218.67,51.04 218.67,41.03 217.64,40.01 J5.8 ; 199.38,70.5 205.86,70.5 207.89,72.53 207.89,76.83 v1(212.09,81.03) ; U15.2 201.73,65.27 ; U15.2 200.6,64.14 ; U15.2 202.87,64.14 ; 214,69.22 J3.3
  ART05 w1.016: U18.2 61.58,141.8 ; U18.2 59.69,143.69 ; U18.2 59.69,139.91
  BOTTOM w0.381: C598.2 75.56,108.46 C40.2 ; C605.2 v1(111.76,34.67) ; C608.2 v1(173.99,34.29) ; U103.5 v1(177.16,174.62) ; C530.2 C531.2
  BOTTOM w0.508: C44.2 120.53,111.88 v1(119.69,112.72) 120.42,113.45 U106.4 120.42,115.24 120.91,115.73 121.69,115.73 ; U106.3 121.69,115.73 ; 121.69,115.73 125.57,115.73 126.24,115.06 C48.2 C47.2 129.93,115.06 C602.2 ; U55.3 201.93,172.6 v1(200.66,171.33) R539.1 ; 123.19,139.7 121.92,138.43 C612.2 ; 123.19,139.7 120.02,142.88 U35.5 ; 123.19,139.7 124.46,139.7 125.96,138.2 134.72,138.2 137.41,140.89 137.41,143.89 138.96,145.44 142.29,145.44 144.76,147.91 144.76,152.23 145.36,152.83 145.36,155.9 144.93,156.33 C1.2 v1(144.15,164.47) ; C93.2 v1(201.67,39.25) ; U104.4 v1(164.47,113.41) ; R70.2 v1(78.11,107.31) ; C26.1 v1(181.71,177.16) ; v1(150.88,36.58) C550.2 C551.2 ; v1(119.97,109.01) 120.53,109.57 R73.2 ; U107.3 v1(124.46,37.85) ; C607.2 v1(154.69,36.58) ; U5.4 81.28,111.57 v1(80.84,111.12) ; v1(104.14,38.1) 103.5,38.73 U108.3 ; U110.3 v1(145.8,37.21) ; v1(100.33,35.18) C544.2 R550.2 ; v1(180.97,171.45) 180.34,170.81 C27.1 ; v1(201.93,43.81) 202.05,43.94 R136.1 ; v1(162.56,34.8) C557.2 R552.2 ; R554.2 C558.2 v1(142.62,34.55) ; C36.2 v1(81.92,107.31) ; C554.2 v1(170.81,36.83) ; U109.4 v1(164.47,37.47) ; C530.2 170.81,115.7 v1(169.93,115.7) ; C595.1 v1(174.62,177.16) ; U110.4 v1(144.53,37.21) ; C35.2 v1(85.72,107.31) ; U2.4 v1(193.55,172.72) 193.8,172.46 C592.2 196.08,171.33 C478.2 ; C532.2 v1(108.58,37.21) ; C597.1 v1(177.16,168.28) ; C43.2 R72.2 164.96,110.47 v1(164.96,109.59) ; v1(121.28,35.18) C543.2 R548.2 ; C601.2 173.74,115.69 C531.2 ; C84.1 v1(195.07,46.15) ; R69.2 v1(79.38,107.31) ; v1(100.97,38.1) 101.73,38.1 102.23,38.61 U108.4 ; C541.2 v1(129.54,35.94) ; R68.2 v1(80.64,107.31) ; C88.2 v1(192.91,24.77) ; U104.3 v1(165.74,113.41) ; R67.2 v1(87,107.31) ; C603.1 v1(182.94,28.51) ; U107.4 v1(123.19,37.85) ; C555.2 v1(170.81,35.56) ; U4.4 v1(198.75,39.37) ; C540.2 v1(129.54,37.21) ; C533.2 v1(108.58,35.94) ; C604.1 v1(186.06,45.72) ; C40.2 v1(75.56,107.31) ; C606.2 v1(126.36,31.75) ; C248.1 v1(190.14,29.72) ; U109.3 v1(165.74,37.47) ; C39.2 v1(76.83,107.31) ; U9.3 v1(205.74,44.2)
  vias: v1(97.28,109.86) v1(100.33,36.58) v1(106.17,109.86) v1(121.28,42.29) v1(123.43,100.24) v1(130.18,100.24) v1(130.94,166.75) v1(130.94,165.61) v1(161.29,42.29) v1(167.78,109.36) v1(171.99,108.19) v1(180.21,99.95) v1(180.21,89.66) v1(182.88,16.89) v1(184.15,16.89) v1(185.42,16.89) v1(186.12,20.23) v1(186.69,16.89) v1(187.96,16.89) v1(189.23,16.89) v1(189.23,15.37) v1(190.5,15.37) v1(190.58,16.74) v1(191.85,16.74) v1(191.9,15.37) v1(193.12,16.74) v1(193.17,15.37) v1(194.39,16.74) v1(194.44,15.37) v1(194.82,86.49) v1(194.82,85.09) v1(195.58,66.1) v1(195.66,16.74) v1(195.71,15.37) v1(196.22,86.49) v1(197.1,16.76) v1(197.1,15.37) v1(197.61,86.49) v1(197.61,85.09) v1(198.12,17.72) v1(198.37,16.76) v1(199.64,16.76) v1(200.91,16.76) v1(201.93,18.36) v1(202.44,16.76) v1(203.2,65.41) v1(204.47,65.41) v1(212.58,51.29)
AGND_N: length 138
  TOP w0.508: C281.2 v1(93.33,139.7) ; C278.1 R243.2 v1(93.34,134.62) ; U34.4 v1(97.28,134.62) ; v1(106.05,133.35) 107.31,133.35 108.58,134.62 C610.1
  GND04 w0.508: v1(163.19,174.62) 161.93,173.35 159.38,173.35 v1(158.12,174.62)
  ART05 w0.508: v1(93.33,139.7) 98.79,139.7 120.78,161.69 131.99,161.69 133.61,163.31 133.61,172.56 138.21,177.16 155.58,177.16 v1(158.12,174.62)
  BOTTOM w0.381: U103.3 163.58,173.35 163.19,173.74 v1(163.19,174.62) U103.4
  BOTTOM w0.508: C29.1 C30.2 159.89,172.09 159.38,171.57 C596.1 158.75,173.99 v1(158.12,174.62) ; R241.1 C280.2 106.17,133.47 v1(106.05,133.35) ; 88.27,136.4 88.27,139.09 88.87,139.7 v1(93.33,139.7) ; C282.1 v1(103.5,140.97) 103.5,142.24 104.49,143.22 105.22,143.22 106.17,142.27 C611.2 ; C524.1 87,121.16 C599.1 ; C279.2 107.06,138.43 107.37,138.12 v1(107.64,138.12) ; v1(82.55,125.73) C497.2 C496.1 ; Q60.3 101.6,136.81 v1(101.6,136.81)
  vias: v1(80.9,138.94) v1(80.9,136.91) v1(83.19,134.62) v1(83.19,133.35) v1(84.45,134.62) v1(84.45,133.35) v1(85.34,136.78) v1(85.72,134.62) v1(85.72,133.35) v1(87,134.62) v1(87,133.35) v1(88.27,134.62) v1(88.27,133.35) v1(89.53,134.62) v1(89.53,133.35) v1(89.79,136.78) v1(90.81,134.62) v1(90.81,133.35) v1(92.08,134.62) v1(92.08,133.35) v1(93.34,133.35) v1(94.61,133.35) v1(95.89,133.35) v1(97.16,133.35)
PGND: length 457.5
  TOP w1.016: 209.56,144.67 C14.2 ; C14.2 214.84,144.67 ; C14.2 212.2,142.03 ; C14.2 212.2,147.31 ; C10.2 157.17,165.93 ; C10.2 154.53,163.28 ; C10.2 151.89,165.93 ; C10.2 154.53,168.57 ; C12.2 154.94,149.9 ; C12.2 152.3,147.26 ; C12.2 157.58,147.26 ; C15.2 191.52,168.45 ; C15.2 191.52,163.16 ; C15.2 194.16,165.8 ; C15.2 188.87,165.8 ; 170.71,147.26 C9.2 ; C9.2 176,147.26 ; C9.2 173.35,149.9 ; C16.2 214.84,163.08 ; C16.2 212.2,165.73 ; C16.2 212.2,160.44 ; C16.2 209.56,163.08 ; 170.46,165.8 C11.2 ; C11.2 173.1,163.16 ; C11.2 173.1,168.45 ; C11.2 175.74,165.8 ; 212.2,123.61 C17.2 ; C17.2 214.84,126.25 ; C17.2 209.56,126.25 ; C17.2 212.2,128.9 ; C13.2 214.84,107.84 ; C13.2 209.56,107.84 ; C13.2 212.2,110.48 ; 188.87,147.39 C18.2 ; C18.2 194.16,147.39 ; C18.2 191.52,150.03 ; 204.92,36.04 CB7.2 207.31,33.66 ; 204.92,48.74 CB6.2 207.31,46.35
  GND04 w0.508: v1(184.78,27.3) 186.69,29.21 v1(186.69,34.92) 186.69,35.56 v1(181.61,40.64)
  GND04 w1.016: C14.2 214.84,144.67 ; C14.2 212.2,147.31 ; C14.2 209.56,144.67 ; C14.2 212.2,142.03 ; C18.2 191.52,150.03 ; C18.2 194.16,147.39 ; C18.2 191.52,144.74 ; C18.2 188.87,147.39 ; C9.2 176,147.26 ; C9.2 173.35,144.62 ; C9.2 173.35,149.9 ; C9.2 170.71,147.26 ; C10.2 154.53,168.57 ; C10.2 151.89,165.93 ; C10.2 157.17,165.93 ; C10.2 154.53,163.28 ; C12.2 157.58,147.26 ; C12.2 154.94,149.9 ; C12.2 152.3,147.26 ; C12.2 154.94,144.62 ; C15.2 191.52,168.45 ; C15.2 194.16,165.8 ; C15.2 191.52,163.16 ; C15.2 188.87,165.8 ; 209.56,126.25 C17.2 ; C17.2 212.2,123.61 ; C17.2 214.84,126.25 ; C17.2 212.2,128.9 ; 209.56,163.08 C16.2 ; C16.2 212.2,160.44 ; C16.2 214.84,163.08 ; C16.2 212.2,165.73 ; 202.54,33.66 CB7.2 ; CB7.2 204.92,36.04 ; CB7.2 207.31,33.66 ; CB6.2 204.92,48.74 ; CB6.2 207.31,46.35 ; CB6.2 202.54,46.35 ; C11.2 175.74,165.8 ; C11.2 173.1,163.16 ; C11.2 170.46,165.8 ; C11.2 173.1,168.45 ; C13.2 214.84,107.84 ; C13.2 212.2,110.48 ; C13.2 212.2,105.2 ; C13.2 209.56,107.84
  ART05 w1.016: 209.56,126.25 C17.2 ; C17.2 212.2,123.61 ; C17.2 212.2,128.9 ; 188.87,147.39 C18.2 ; C18.2 191.52,144.74 ; C18.2 191.52,150.03 ; C18.2 194.16,147.39 ; C12.2 157.58,147.26 ; C12.2 154.94,149.9 ; C12.2 154.94,144.62 ; C12.2 152.3,147.26 ; 154.53,163.28 C10.2 157.17,165.93 ; 212.2,110.48 C13.2 209.56,107.84 ; C9.2 173.35,149.9 ; C9.2 170.71,147.26 ; C9.2 173.35,144.62 ; C9.2 176,147.26 ; 191.52,163.16 C15.2 ; C15.2 188.87,165.8 ; C15.2 194.16,165.8 ; 170.46,165.8 C11.2 ; C11.2 173.1,163.16 ; C11.2 175.74,165.8 ; 212.2,142.03 C14.2 ; C14.2 212.2,147.31 ; C14.2 209.56,144.67 ; 209.56,163.08 C16.2 212.2,160.44
  BOTTOM w0.508: C90.2 C89.2 v1(186.69,34.92) ; C99.1 203.27,30.53 203.27,31.23 203.54,31.5 205.48,31.5 206.45,30.53 206.45,28.07 205.05,26.67 C92.2 R129.1 203.32,24.13 201.7,22.5 186.95,22.5 185.93,23.52 C82.1 184.69,24.77 183.93,25.52 183.93,26.45 v1(184.78,27.3) R123.2 C87.1 ; R66.2 C34.2 67.37,107.82 66.86,108.34 66.86,111.49 67.36,112 68.07,112 68.58,112.5 C37.1 ; C37.1 70.02,113.53 70.77,112.78 ZD13.2 ; C37.1 61.68,113.53 60.67,114.55 ; 182.24,62.48 180.73,62.48 179.55,61.29 179.55,54.12 179.83,53.83 C81.1 179.83,51.73 178.31,50.21 178.31,43.02 180.69,40.64 v1(181.61,40.64) R135.2 182.73,40.67 182.73,41.55 183.09,41.91 C96.2
  BOTTOM w1.016: C11.2 173.1,167.68 ; C11.2 173.1,163.92 ; C11.2 174.98,165.8 ; C11.2 171.22,165.8 ; 154.53,164.05 C10.2 ; C10.2 156.41,165.93 ; C10.2 154.53,167.81 ; C10.2 152.65,165.93 ; 171.47,147.26 C9.2 ; C9.2 173.35,149.14 ; C9.2 175.24,147.26 ; C12.2 156.82,147.26 ; C12.2 154.94,149.14 ; C12.2 153.06,147.26 ; 191.52,149.27 C18.2 189.63,147.39 ; C15.2 191.52,167.68 ; C15.2 189.63,165.8 ; C15.2 193.4,165.8 ; C15.2 191.52,163.92 ; 210.32,163.08 C16.2 212.2,161.2
  vias: v1(102.87,125.73) v1(102.87,124.46) v1(104.78,125.73) v1(184.15,70.48) v1(184.15,69.22) v1(184.15,67.94) v1(184.15,66.67) v1(184.15,65.41) v1(184.15,64.14) v1(184.15,62.87) v1(184.15,61.59) v1(184.15,60.33) v1(184.15,59.05) v1(184.15,57.78) v1(184.15,56.52) v1(184.78,99.69) v1(184.78,98.42) v1(184.78,97.16) v1(184.78,95.89) v1(184.78,94.61) v1(184.78,93.34) v1(184.78,92.08) v1(184.78,90.81) v1(184.78,89.53) v1(185.42,70.48) v1(185.42,69.22) v1(185.42,67.94) v1(185.42,66.67) v1(185.42,65.41) v1(185.42,64.14) v1(185.42,62.87) v1(185.42,61.59) v1(185.42,60.33) v1(185.42,59.05) v1(185.42,57.78) v1(185.42,56.52) v1(186.06,99.69) v1(186.06,98.42) v1(186.06,97.16) v1(186.06,95.89) v1(186.06,94.61) v1(186.06,93.34) v1(186.06,92.08) v1(186.06,90.81) v1(186.06,89.53) v1(204.47,159.39) v1(204.47,158.12) v1(204.47,156.84) v1(204.47,155.57) v1(204.47,154.31) v1(205.74,159.39) v1(205.74,158.12) v1(205.74,156.84) v1(205.74,155.57) v1(205.74,154.31) v1(207.01,159.38) v1(207.01,158.12) v1(207.01,156.84) v1(207.01,155.57) v1(207.01,154.31)
SGND: length 83.1
  TOP w0.508: U10.9 v1(91.44,38.1) ; C100.2 v1(85.72,27.82) ; C103.1 v1(88.78,26.79)
  GND04 w0.508: 212.86,20.95 214,20.95 ; 214,20.95 214,19.82 ; 214,20.95 215.13,20.95 ; 212.86,15.88 214,15.88 ; 214,15.88 214,17.01 ; 214,15.88 215.13,15.88 ; 214,15.88 214,14.74 ; 96.46,5.71 U23.2 ; U23.2 97.59,4.58 ; U23.2 98.73,5.71 ; U23.2 97.59,6.85 ; U22.2 86.66,5.71 ; U22.2 85.53,6.85 ; U22.2 84.4,5.71 ; U22.2 85.53,4.58 ; 109.66,4.58 U24.2 ; U24.2 110.79,5.71 ; U24.2 109.66,6.85 ; U24.2 108.53,5.71 ; 132.68,7.62 J8.5 ; J8.5 133.81,6.49 ; J8.5 133.81,8.75 ; J8.5 134.94,7.62 ; 216.53,13.34 216.53,14.47 ; 216.53,13.34 216.53,12.2 ; 216.53,13.34 217.67,13.34 ; 216.53,13.34 215.4,13.34
  ART05 w0.508: U22.2 86.66,5.71 ; U22.2 84.4,5.71 ; U22.2 85.53,4.58 ; U22.2 85.53,6.85 ; 109.66,4.58 U24.2 ; U24.2 110.79,5.71 ; U24.2 108.53,5.71 ; U24.2 109.66,6.85 ; U23.2 97.59,6.85 ; U23.2 96.46,5.71 ; U23.2 97.59,4.58 ; U23.2 98.73,5.71 ; J8.5 134.94,7.62 ; J8.5 132.68,7.62 ; J8.5 133.81,6.49
  BOTTOM w0.508: U114.4 v1(57.78,37.85) ; U113.4 v1(78.74,37.85) ; R558.2 C572.2 v1(15.24,35.18) ; v1(76.83,35.18) C585.2 R560.2 ; U113.3 v1(80.01,37.85) ; R563.2 C586.2 v1(55.88,35.18) ; C569.2 v1(44.45,35.94) ; v1(36.2,35.18) C571.2 R556.2 ; C578.2 v1(64.14,37.21) ; U112.4 v1(17.14,37.85) ; U112.3 v1(18.41,37.85) ; U114.3 v1(59.05,37.85) ; C564.2 v1(23.5,37.21) ; C568.2 v1(44.45,37.21) ; C582.2 v1(85.09,37.21) ; C579.2 v1(64.14,35.94) ; U111.3 v1(39.37,37.85) ; U111.4 v1(38.1,37.85) ; C583.2 v1(85.09,35.94) ; C565.2 v1(23.5,35.94)
  vias: v1(86.87,7.24) v1(88.14,7.24) v1(89.41,7.24) v1(90.68,7.24) v1(98.93,7.24) v1(100.2,7.24) v1(101.47,7.24) v1(102.74,7.24) v1(111,7.24) v1(112.27,7.24) v1(113.54,7.24) v1(114.81,7.24) v1(121.92,2.54) v1(123.19,2.54)
_PFCREF1.6V: length 14.8
  BOTTOM w0.508: U2.1 193.22,176.53 193.68,176.08 193.68,175.6 193.34,175.26 U2.2 190.79,175.26 186.85,171.33 R537.2 C28.1
_PREF1.6V: length 13.1
  ART03 w0.508: v1(195.94,41.91) 190.35,36.33 v1(190.35,36.06)
  BOTTOM w0.508: U4.1 196.09,43.18 195.88,42.98 195.88,41.96 v1(195.94,41.91) U4.2 ; R119.1 189.24,36.06 v1(190.35,36.06)
AC_L: length 89.1
  ART02 w1.016: D2.2 43.27,131.28 ; D2.2 43.27,126.5 ; D2.2 45.65,128.89 ; 120.6,156.16 RLY1.3 ; RLY1.3 124.25,159.8 ; RLY1.3 127.89,156.16 ; RLY1.3 124.25,152.51 ; 120.25,146.01 XC4.1 ; XC4.1 122.63,148.39 ; XC4.1 125.02,146.01 ; 132.92,141.64 RV2.1 130.5,144.06
  ART03 w1.016: RV2.1 130.5,144.06 ; RV2.1 128.09,141.64 ; RV2.1 130.5,139.23 ; RV2.1 132.92,141.64 ; 124.25,152.51 RLY1.3 120.6,156.16 ; XC4.1 125.02,146.01 ; XC4.1 122.63,148.39 ; XC4.1 122.63,143.62 ; XC4.1 120.25,146.01
  GND04 w1.016: 128.09,141.64 RV2.1 ; RV2.1 130.5,144.06 ; RV2.1 132.92,141.64 ; 43.27,131.28 D2.2 45.65,128.89 ; XC4.1 122.63,148.39 ; XC4.1 122.63,143.62 ; XC4.1 125.02,146.01 ; XC4.1 120.25,146.01 ; 120.6,156.16 RLY1.3 124.25,152.51
AC_L_SAMP: length 6.1
  BOTTOM w0.508: RLY1.4 124.7,173.96 125.37,174.62 R14.1
AC_L_SAMP_D: length 177.5
  ART05 w0.508: 214,79.38 214.55,79.38 215.82,80.64 217.17,80.64 218.74,82.22 218.74,168.35 209.04,178.05 174.02,178.05 168.46,172.5 143.73,172.5 v1(142.24,173.99)
  BOTTOM w0.508: R16.2 141.6,174.62 v1(142.24,173.99)
AC_N_D: length 210
  ART05 w0.508: v1(115.57,149.86) 123.69,149.86 135.24,161.41 135.24,164.37 142.61,171.74 170.4,171.74 175.75,177.09 180.58,177.09 181.44,176.24 186.6,176.24 187.43,177.06 208.38,177.06 217.81,167.64 217.81,83.92 217.07,83.19 215.24,83.19 214,81.94 214,81.92
  BOTTOM w0.508: R22.2 v1(115.57,149.86)
AD_DC_CUR: length 60.9
  ART03 w0.508: v1(189.87,41.91) 190.21,41.91 191.91,43.6 191.91,45.97 208.43,62.5 208.43,82.55 212.88,87 214,87
  BOTTOM w0.508: C94.2 R132.2 188.72,42.29 189.1,41.91 v1(189.87,41.91) U4.7
CAN5V_GND: length 79.4
  ART03 w0.508: J8.2 146.4,2.65 176.47,2.65 178.83,5.01 178.83,7.41 182.01,10.6 213.8,10.6 214,10.79
CAN_5V: length 78.2
  ART03 w0.508: J8.1 148.06,3.53 175.68,3.53 177.94,5.8 177.94,7.97 181.72,11.74 202.24,11.74 205.23,14.73 212.6,14.73 214,13.34
CLAMPA: length 33.3
  ART05 w0.508: Q3.1 181.84,125.78 177.76,121.69 v1(167,121.69) 163.22,121.69 158.6,126.31 Q2.1
  BOTTOM w0.508: U104.7 v1(167,121.69)
CLAMPB: length 33.8
  ART05 w0.508: Q7.1 138.91,126.33 136.23,123.65 125.09,123.65 v1(122.96,121.51) 120.65,123.83 117.13,123.83 115.67,125.29 Q6.1
  BOTTOM w0.508: U106.7 v1(122.96,121.51)
CLAMPQ8: length 9.5
  BOTTOM w0.508: 19.68,45.19 19.68,45.79 17.9,47.57 17.14,47.57 16.79,47.92 Q8.1 16.64,49.66 R78.1
CLAMPQ9: length 9.3
  BOTTOM w0.508: U114.7 60.33,46.24 59.58,46.99 59.38,46.99 58.42,47.95 58.42,48.76 Q9.1 57.52,49.66 R79.2
CLAMPQ10: length 12.3
  BOTTOM w0.508: U108.7 104.78,46.19 103.94,47.03 103.72,47.03 103,47.74 103,48.49 102.11,49.38 Q10.1 100.95,50.68 R80.1 R564.1
CLAMPQ11: length 14.6
  BOTTOM w0.508: U110.7 147.07,45.26 146.61,45.72 146.49,45.77 146.2,45.77 144.85,47.12 144.02,47.12 143.51,47.62 143.51,48.96 Q11.1 ; R565.2 142.81,49.66 Q11.1 ; Q11.1 141.99,48.55 R81.2
CLAMPQ12: length 9.3
  BOTTOM w0.508: R94.1 37.85,49.66 Q12.1 38.73,48.77 38.73,47.88 39.58,47.03 39.8,47.03 40.64,46.19 U111.7
CLAMPQ13: length 9.7
  BOTTOM w0.508: R95.2 75.18,49.41 78.51,49.41 78.62,49.52 ; 78.62,49.52 78.62,49.38 79.51,48.49 79.51,47.74 80.22,47.03 80.44,47.03 81.28,46.19 U113.7 ; 78.62,49.52 Q13.1
CLAMPQ14: length 11.8
  BOTTOM w0.508: U107.7 125.73,46.19 124.89,47.03 124.67,47.03 123.96,47.74 123.96,48.84 Q14.1 122.12,50.68 R97.1 R566.1
CLAMPQ15: length 12.5
  BOTTOM w0.508: R567.2 R98.2 163.13,50.55 Q15.1 165.01,48.67 165.01,47.56 165.52,47.05 165.77,47.05 167,45.81 U109.7
DCOCP: length 72.5
  ART03 w0.508: v1(194.31,31.11) 196.8,33.61 196.8,43.94 217.86,65 217.86,87.68 217.27,88.27 215.26,88.27 214,89.53
  BOTTOM w0.508: D8.3 v1(194.31,31.11)
DCPWM1A_1H: length 144.4
  ART05 w0.381: J5.4 217.73,43.89 217.73,42.05 216.96,41.28 216.13,41.28 215.25,40.41 215.25,39.39 214.63,38.77 213.41,38.77 211.74,37.1 211.74,32.7 210.47,31.42 210.47,29.31 200.5,19.34 181.77,19.34 177.71,15.28 166.72,15.28 165.17,13.72 127.02,13.72 123.64,17.1 123.64,19.53 110.62,32.55 v1(110.62,33.15)
  BOTTOM w0.508: R551.1 104.14,34.29 104.69,33.74 110.02,33.74 v1(110.62,33.15)
DCPWM1A_1L: length 121.8
  ART05 w0.381: J5.2 215.26,46.35 215.26,41.93 214.62,41.28 210.96,41.28 207.96,38.28 207.96,30.73 199.55,22.32 180.16,22.32 179,21.15 149.97,21.15 144.76,26.36 144.76,34.45 143.72,35.49 130.4,35.49 128.94,34.04 v1(125.09,34.04)
  BOTTOM w0.508: R549.1 v1(125.09,34.04)
DCPWM2A_2H: length 97.6
  ART05 w0.381: v1(142.62,33.02) 143.51,32.13 143.51,26.08 149.33,20.25 179.18,20.25 180.28,21.36 199.97,21.36 208.88,30.27 208.88,37.43 211.46,40.01 214,40.01
  BOTTOM w0.381: R555.1 146.43,33.66 145.8,33.02 v1(142.62,33.02)
DCPWM2A_2L: length 72.3
  ART05 w0.381: 214,42.55 210.76,42.55 206.96,38.75 206.96,31.08 199.18,23.29 178.38,23.29 177.3,22.2 167.83,22.2 166.37,23.67 v1(166.37,33.66)
  BOTTOM w0.508: R553.1 v1(166.37,33.66)
DRV_L_G: length 70.6
  ART03 w0.508: v1(175.9,42.55) 174.71,41.36 159.45,41.36 158.78,42.03 136.92,42.03 v1(136.53,42.43)
  ART05 w0.381: U21.6 176.64,33.83 176.64,41.8 v1(175.9,42.55)
  BOTTOM w0.508: C559.2 C561.1 173.6,43.06 R542.2 175.9,42.82 v1(175.9,42.55) ; C547.1 133.47,43.31 C545.2 133.97,42.82 R541.1 136.14,42.82 v1(136.53,42.43)
DRVA: length 8.3
  BOTTOM w0.508: 99.94,45.66 D57.2 ; 99.94,45.66 99.94,46.46 98.53,47.88 R80.2 ; 99.94,45.66 100.63,45.66 101.71,46.74 102.87,46.74 103.5,46.1 U108.6
DRVA_G: length 50.3
  TOP w0.508: R85.1 C56.2
  GND04 w1.016: T1.9 93.11,83.09 ; T1.9 89.21,87.98 ; T1.9 85.31,83.09
  ART05 w0.508: v1(111.76,43.81) 111.76,39.77 122.99,28.54 130.07,28.54 U19.6
  BOTTOM w0.508: C537.1 C536.2
  BOTTOM w0.762: Q10.3 112.99,45.05 v1(111.76,43.81) 111.38,43.44 C537.1
DRVB: length 8
  BOTTOM w0.508: R97.2 120.9,47 D59.2 121.15,45.72 121.65,45.72 122.67,46.74 123.83,46.74 124.46,46.1 U107.6
DRVC: length 11.3
  BOTTOM w0.508: D58.2 140.72,40.39 141.99,41.66 R81.1 143.15,43.18 143.5,43.54 143.5,45.34 143.64,45.47 143.64,45.47 144.14,45.97 144.91,45.97 145.8,45.09 U110.6
DRVC_G: length 28.9
  ART05 w0.381: U20.6 146.87,29.46 146.87,35.24 154.05,42.42 154.05,42.8 v1(154.05,42.8)
  BOTTOM w0.762: C553.2 C552.1 v1(154.05,42.8) 154.92,43.67 154.92,48.43 Q11.3
DRVD: length 8.4
  BOTTOM w0.508: U109.6 165.74,45.72 165.1,46.35 163.94,46.35 162.92,45.34 D60.2 162.17,46.64 161.06,47.75 R98.1
DRVSA: length 6.1
  BOTTOM w0.508: R78.2 13.58,46.62 17.6,46.62 18.41,45.8 U112.6
DRVSB: length 6.3
  BOTTOM w0.508: U111.6 39.37,46.1 38.73,46.74 34.41,46.74 R94.2
DRVSC: length 6.3
  BOTTOM w0.508: R79.1 54.1,46.74 58.43,46.74 59.05,46.11 U114.6
DRVSD: length 6.3
  BOTTOM w0.508: R95.1 75.05,46.74 79.38,46.74 80.01,46.1 U113.6
EARTH:
  vias: v1(17.14,158.75) v1(17.14,157.48) v1(17.14,156.21) v1(17.14,154.94) v1(59.18,162.56) v1(59.18,161.29) v1(60.33,162.56) v1(60.33,161.29)
IPFC: length 103
  TOP w0.508: R244.2 v1(93.32,140.97)
  ART05 w0.508: v1(160.53,174.62) 157,178.15 137.58,178.15 132.78,173.36 132.78,163.78 131.65,162.64 120.1,162.64 98.42,140.97 v1(93.32,140.97)
  BOTTOM w0.508: 88.27,143 88.27,141.63 88.93,140.97 v1(93.32,140.97) ; XC4.2 100.13,147.76 100.83,148.46 R20.1 ; v1(160.53,174.62) R62.2
  vias: v1(88.27,149.86) v1(88.27,148.59) v1(88.27,147.32) v1(88.27,146.05) v1(88.27,144.78) v1(89.53,149.86) v1(89.53,148.59) v1(89.53,147.32) v1(89.53,146.05) v1(89.53,144.78) v1(90.81,149.86) v1(90.81,148.59) v1(90.81,147.32) v1(90.81,146.05) v1(90.81,144.78) v1(92.08,149.86) v1(92.08,148.59) v1(92.08,147.32) v1(92.08,146.05) v1(92.08,144.78) v1(93.34,147.32) v1(93.34,146.05) v1(93.34,144.78) v1(94.61,147.32) v1(94.61,146.05) v1(94.61,144.78) v1(95.89,147.32) v1(95.89,146.05) v1(95.89,144.78) v1(97.16,147.32) v1(97.16,146.05) v1(97.16,144.78)
IPFCSAMPLE: length 119
  BOTTOM w0.508: R65.1 C31.2 184.93,175.77 185.43,175.26 U2.7 187.85,175.26 190.15,177.56 206.7,177.56 218.8,165.46 218.8,91.8 J3.17
PCS+: length 73.2
  GND04 w0.508: v1(204.29,29.51) 202.69,27.91 189.38,27.91 187.5,26.04 v1(184.78,26.04) 183.82,27 183.82,31.06 185.17,32.4 185.17,35.81 v1(181.61,39.37)
  BOTTOM w0.508: v1(204.29,29.51) 203.99,29.21 R138.2 ; R120.2 v1(181.61,39.37) 180.76,39.37 177.53,42.6 177.53,50.62 178.31,51.4 C81.2 178.31,53.61 178.68,53.99 178.68,61.33 177.47,62.54 175.9,62.54 ; v1(184.78,26.04) R117.2
  BOTTOM w0.762: Q14.3 135.25,48.42 R541.2
  vias: v1(168.91,71.12) v1(168.91,69.85) v1(168.91,68.58) v1(170.18,71.12) v1(170.18,69.85) v1(170.18,68.58) v1(171.45,71.12) v1(171.45,69.85) v1(171.45,68.58) v1(172.72,71.12) v1(172.72,69.85) v1(172.72,68.58) v1(173.99,71.12) v1(173.99,69.85) v1(173.99,68.58)
PFC-FB: length 15.3
  BOTTOM w0.508: J3.23 215.26,98.42 215.26,106.04 215.9,106.68 R43.1
PFC-VO: length 6.3
  BOTTOM w0.508: 214,97.16 210.95,100.2 R45.1
PFC_G_A: length 72
  ART03 w0.508: v1(192.28,96.39) 194.59,98.7 194.59,104.54 175.31,123.83 v1(168.28,123.83) 151.13,123.83 v1(147.96,120.65)
  BOTTOM w0.508: v1(168.28,123.83) 167.64,124.46 R35.1 167.2,125.37 166.07,126.49 C499.1 C498.2 ; R34.1 v1(147.96,120.65)
PFC_G_B: length 35
  BOTTOM w0.508: R234.2 114.15,113.97 R75.2 ZD14.2 116.36,116.49 C42.2 C45.1 ; C45.1 117.9,119.17 119.38,120.65 119.38,121.86 120.93,123.41 120.93,124.16 122.5,125.73 R60.1 ; C45.1 106.89,119.17 104.78,121.28 R56.1
PFC_OCP: length 15.5
  ART05 w0.508: v1(216.53,100.33) 215.26,99.05 215.26,88.27 J3.15
  BOTTOM w0.508: R248.1 v1(216.53,100.33)
PFCDRVA: length 31.8
  BOTTOM w0.508: 165.74,118.56 164.97,117.79 161.61,117.79 159.12,120.28 159.12,123.69 R27.1 ; 165.74,118.56 U104.6 ; 165.74,118.56 166.53,117.77 168.69,117.77 171.2,120.27 180.46,120.27 R28.1
PFCDRVB: length 25.6
  ART05 w0.508: v1(121.69,121.54) 120.42,122.81 v1(118.36,122.81)
  BOTTOM w0.508: v1(121.69,121.54) U106.6 121.69,119.11 122.18,118.62 135.03,118.62 136.39,119.98 R52.1 ; v1(118.36,122.81) 117.84,123.33 117.47,123.33 116.71,124.1 R51.1
PFCDRVC: length 17.8
  BOTTOM w0.508: R29.1 96.52,117.88 95.24,116.6 84.31,116.6 83.82,117.09 U5.15
PFCDRVD: length 6.7
  ART05 w0.508: v1(74.6,121.15) 76.33,121.15 v1(77.47,120.02)
  BOTTOM w0.508: R48.1 v1(74.6,121.15) ; U5.10 v1(77.47,120.02)
PFCREF1.6V: length 15.2
  BOTTOM w0.508: U2.3 193.55,173.99 193.8,174.25 C592.1 195.45,174.25 C478.1 R540.2 198.12,174.5 R538.2 198,175.26 198.82,176.09 202.37,176.09 202.88,175.58 U55.2
PREF1.6V: length 8
  BOTTOM w0.508: U9.2 204.63,40.76 C93.1 202.49,40.76 202.11,41.15 R128.2 R126.2 199.33,41.15 198.82,40.64 U4.3
PWM1A: length 80.6
  ART05 w0.508: v1(169.42,108.58) 178.94,99.06 178.94,89.09 198.39,69.64 206.24,69.64 209.18,72.59 209.18,76.49 213.33,80.64 214.66,80.64 215.93,81.92 J3.11
  BOTTOM w0.508: R71.1 168.91,111.88 169.42,111.38 v1(169.42,108.58)
PWM1B: length 121
  ART05 w0.508: J3.5 215.26,73.02 213.23,73.02 207.23,67.02 195.93,67.02 187.99,74.96 160.8,74.96 146.22,89.53 132.08,89.53 124.46,97.16 124.46,104.14 v1(123.83,104.78)
  BOTTOM w0.508: R74.1 v1(123.83,104.78)
PWM1C: length 160.6
  ART05 w0.508: J3.7 215.27,75.57 213.49,75.57 211.47,73.54 211.47,72.49 206.8,67.82 196.89,67.82 188.24,76.48 161.45,76.48 147.12,90.81 133.35,90.81 126.36,97.79 126.36,104.14 119.59,110.92 88.06,110.92 v1(84.45,107.31)
  BOTTOM w0.508: R251.1 v1(84.45,107.31)
PWM1D: length 163.9
  ART05 w0.508: J3.9 215.26,78.11 213.49,78.11 210.47,75.09 210.47,72.65 206.58,68.75 197.67,68.75 188.53,77.9 162.08,77.9 147.94,92.04 133.75,92.04 127.53,98.26 127.53,104.88 120.65,111.76 87.63,111.76 v1(83.19,107.31)
  BOTTOM w0.508: R250.1 v1(83.19,107.31)
RLYCTRL1: length 160.9
  ART05 w0.508: 214,94.61 213.97,94.61 212.49,96.1 212.49,99.08 215.77,102.36 215.77,165.99 207.56,174.21 180.76,174.21 179.56,175.4 176.88,175.4 171.49,170.01 144.07,170.01 v1(138.53,164.47)
  BOTTOM w0.508: R5.2 v1(138.53,164.47)
SPGND: length 60.4
  TOP w1.016: C63.2 64.36,30.9 ; C63.2 62.23,28.76 ; C63.2 60.1,30.9 ; C63.2 62.23,33.03 ; 74.07,30.9 C66.2 ; C66.2 78.33,30.9 ; C66.2 76.2,28.76 ; C66.2 76.2,33.03
  ART02 w0.508: C72.2 27.94,33.57 ; C72.2 27.94,29.81 ; C72.2 26.06,31.69 ; C72.2 29.82,31.69 ; C78.2 46.35,33.57 ; C78.2 46.35,29.81 ; C78.2 48.24,31.69 ; C78.2 44.47,31.69 ; 62.23,28.76 C63.2 ; C63.2 64.36,30.9 ; C63.2 60.1,30.9 ; C63.2 62.23,33.03 ; C66.2 76.2,33.03 ; C66.2 78.33,30.9 ; C66.2 74.07,30.9 ; C66.2 76.2,28.76
  ART02 w1.016: Q12.3 48.87,51.29 ; Q12.3 48.87,47.74 ; Q12.3 50.65,49.52
  BOTTOM w0.508: C72.2 29.95,31.69 30.39,31.25 R107.2
  vias: v1(57.78,31.75) v1(57.78,30.48) v1(57.78,29.21) v1(57.78,27.94) v1(58.97,21.35) v1(58.97,20.08) v1(59.05,31.75) v1(59.05,30.48) v1(59.05,29.21) v1(59.05,27.94) v1(60.24,21.35) v1(60.24,20.08) v1(61.51,21.35) v1(61.51,20.08) v1(63.42,21.35) v1(63.42,20.08) v1(64.69,21.35) v1(64.69,20.08) v1(65.96,21.35) v1(65.96,20.08) v1(68.58,32.38) v1(68.58,31.11) v1(69.85,32.38) v1(69.85,31.11) v1(71.12,32.38) v1(71.12,31.11)
SR-PWM-A: length 144.4
  TOP w0.508: R141.2 v1(107.95,30.48)
  ART05 w0.381: v1(107.95,30.48) 115.83,22.6 115.83,18.28 123.24,10.87 200.14,10.87 205.49,16.22 205.49,19.2 213.36,27.07 213.36,30.2 215.1,31.94 216.72,31.94 218.36,33.59 218.36,37.32 217.03,38.66 215.86,38.66 214.66,37.47 214,37.47
SR-PWM-A-S: length 76.6
  TOP w0.508: R142.2 v1(87.63,30.48)
  ART05 w0.508: v1(19.05,33.66) 24.51,28.19 54.01,28.19 56.69,25.51 78.78,25.51 83.75,30.48 v1(87.63,30.48)
  BOTTOM w0.508: R559.1 v1(19.05,33.66)
SR-PWM-B: length 138.3
  TOP w0.508: R143.2 v1(107.95,31.75)
  ART05 w0.381: v1(107.95,31.75) 118,21.7 118,17.96 124.45,11.51 199.57,11.51 204.59,16.52 204.59,19.52 212.67,27.61 212.67,30.53 215.06,32.91 216.74,32.91 217.73,33.9 217.73,36.27 J5.10
SR-PWM-B-S: length 55
  TOP w0.508: R144.2 v1(87.63,31.75)
  ART05 w0.508: v1(87.63,31.75) 83.02,31.75 77.85,26.58 57.2,26.58 54.44,29.34 44.96,29.34 v1(40.01,34.29)
  BOTTOM w0.508: R557.1 v1(40.01,34.29)
SR-PWM-C: length 131.8
  TOP w0.508: R145.2 v1(107.95,33.02)
  ART05 w0.381: v1(107.95,33.02) 119.73,21.24 119.73,17.86 125.45,12.14 198.96,12.14 203.45,16.63 203.45,19.69 211.99,28.22 211.99,30.87 214,32.88 214,34.92
SR-PWM-C-S: length 30.7
  TOP w0.508: R146.2 v1(87.63,33.02)
  ART05 w0.508: v1(87.63,33.02) 79.59,33.02 78.95,33.66 60.07,33.66 v1(59.69,34.04)
  BOTTOM w0.508: R562.1 v1(59.69,34.04)
SR-PWM-D: length 133.6
  TOP w0.508: v1(109.22,33.02) 107.95,34.29 R147.2
  ART05 w0.381: J5.12 215.34,36.12 213.5,36.12 212.71,35.33 212.71,32.58 211.23,31.1 211.23,28.75 200.93,18.45 182.53,18.45 176.86,12.78 126.43,12.78 121.83,17.37 121.83,20.24 109.22,32.85 v1(109.22,33.02)
SR-PWM-D-S: length 9.4
  TOP w0.508: R148.2 v1(87.63,34.29)
  ART05 w0.508: v1(80.64,34.29) 81.06,33.87 87.21,33.87 v1(87.63,34.29)
  BOTTOM w0.508: R561.1 v1(80.64,34.29)
SR_DETA_PRI: length 196
  ART03 w0.508: v1(87.5,59.82) 93.95,53.37 93.95,29.87 102.78,21.04 117.58,21.04 126.3,12.32 175.56,12.32 184.58,21.34 202.15,21.34 211.61,30.79 211.61,37.05 210.84,37.82 210.84,44.47 214,47.62
  BOTTOM w0.381: D61.2 90.49,65.03 90.17,65.35 86.34,65.35 D62.2 85.41,62.54 86.36,61.59 R568.2
  BOTTOM w0.508: R568.2 v1(87.5,59.82)
SR_DETB_PRI: length 195.8
  ART03 w0.508: 214,45.09 212.72,43.81 212.72,29.8 202.21,19.29 184,19.29 175.9,11.18 125.82,11.18 116.96,20.03 102.04,20.03 92.85,29.21 92.85,52.56 v1(87.63,57.78)
  BOTTOM w0.381: D61.1 92.39,62.54 91.44,61.59 R568.1 90.3,62.84 89.64,63.5 88.23,63.5 D62.1
  BOTTOM w0.508: v1(87.63,57.78) 90.3,60.46 R568.1
SR_L_G: length 91.7
  ART05 w0.508: v1(49.53,43.18) 50.24,42.47 v1(90.73,42.47) 98.61,34.59 98.61,28.14 106.32,20.43 110.47,20.43 111.45,19.45 111.45,17.54 109.79,15.88 U24.6
  BOTTOM w0.508: v1(90.73,42.47) 90.65,42.55 C587.2 89.16,44.07 C589.1 90.69,44.2 R544.2 ; C573.2 46.35,42.55 47.75,43.94 C575.1 49.26,44.45 R543.1 v1(49.53,43.18)
SRA_G: length 105.3
  ART02 w0.508: U22.6 55.88,15.88 52.38,19.38 25.8,19.38 21.19,23.98 21.19,38.95 27.66,45.42 Q8.3
  BOTTOM w0.508: C567.2 C566.1
  BOTTOM w0.762: Q8.3 27.66,44.56 26.55,43.44 C566.1
SRC_G: length 81.9
  ART02 w0.508: Q9.3 68.54,51.13 73.86,56.45 91.68,56.45 94.43,53.7 94.43,24.85 99.89,19.4 99.89,16.84 98.92,15.88 U23.6
  BOTTOM w0.508: C581.2 C580.1
  BOTTOM w0.762: C580.1 66.93,43.44 68.54,45.04 Q9.3
VDCLOW+15V: length 60
  ART03 w0.508: v1(135.25,41.27) 136.48,40.05 174.67,40.05 v1(175.9,41.27)
  ART05 w0.381: v1(175.9,41.27) 175.9,34.58 170.52,29.21 U21.7
  BOTTOM w0.508: R590.2 v1(135.25,41.27) ; v1(175.9,41.27) 175.54,41.63 174.63,41.63 R588.2
VLOW+15V: length 188
  ART05 w0.508: U15.7 204.09,79.19 204.09,100.28 190.07,114.3 169.54,114.3 165.42,118.42 131.5,118.42 v1(128,121.92) 123.55,117.47 v1(118.75,117.47) 116.74,115.47 76.46,115.47 v1(74.93,113.94)
  BOTTOM w0.508: v1(118.75,117.47) 118.75,114.94 117.98,114.17 C42.1 116.84,111.76 116.35,111.27 R75.1 111.76,111.27 R234.1 ; R581.2 v1(128,121.92) ; C34.1 R66.1 71.22,110.62 72.7,112.1 72.7,113.08 73.56,113.94 R577.2 v1(74.93,113.94)
VO1+: length 185.9
  ART05 w0.508: v1(53.98,2.54) 59.69,8.26 80.64,8.26 82.38,6.52 82.38,2.07 83.5,0.95 143.19,0.95 151.52,9.28 206.76,9.28 209.88,12.4 209.88,19.36 212.74,22.23 215.26,22.23 216.53,23.5
  BOTTOM w0.508: R570.2 54.11,2.41 v1(53.98,2.54)
VO2+: length 76
  ART05 w0.508: v1(149.99,4.95) 152.4,2.54 175.26,2.54 180.97,8.26 208.28,8.26 211.46,11.43 211.46,15.88 214,18.41
  BOTTOM w0.508: R118.2 v1(149.99,4.95)
VO+: length 13.1
  BOTTOM w0.508: C58.1 46.35,6.99 49.66,10.29 R571.1 ; R84.1 30.77,4.95 29.95,5.77 C55.1
  vias: v1(66.67,6.35) v1(67.94,6.35) v1(69.22,6.35) v1(70.48,6.35) v1(71.75,6.35) v1(73.03,6.35) v1(74.3,6.35) v1(75.56,6.35) v1(76.83,6.35) v1(78.11,6.35)
VP+5V: length 645.1
  TOP w0.508: R545.1 111.88,33.08 109.86,35.11 v1(109.86,35.94)
  ART03 w0.381: v1(204.34,39.62) 207.01,36.96 207.01,36.83
  ART03 w0.508: 207.01,36.83 207.01,30.48 201.81,25.28 v1(198.88,25.28) ; v1(200.03,43.81) 200.15,43.81 v1(204.34,39.62)
  ART03 w1.016: 214,92.08 206.98,85.06 206.98,63.6 v1(190.38,46.99) 189.23,45.84 189.23,42.93 184.38,38.07 179.98,38.07 174.93,33.02 v1(171.33,33.02) 168.4,35.94 157.1,35.94 156.08,34.92 v1(151.13,34.92) 147.19,34.92 146.43,35.69 130.94,35.69 128.27,33.02 115.57,33.02 112.65,35.94 v1(109.86,35.94)
  GND04 w0.508: v1(180.97,169.54) 178.67,171.85 v1(178.67,174.61) ; v1(198.88,25.28) 205.13,25.28 209.3,21.11 209.3,15.14 C594.1
  ART05 w0.508: v1(175.38,112.52) 168.13,112.52 163.43,117.22 136.27,117.22 v1(132.72,113.67) 132.03,114.35 77.3,114.35 74.66,111.71 74.66,108.99 73.03,107.36 v1(73.03,107.31) ; v1(124.46,137.28) 124.46,141.06 128.7,145.3 130.74,145.3 140.95,155.51 140.95,165.52 144.6,169.17 173.23,169.17 v1(178.67,174.61) ; 214,92.08 211.46,92.08 207.65,95.89 207.65,100.97 191.89,116.72 v1(175.38,116.72)
  BOTTOM w0.381: 72.65,108.71 R575.1 ; 72.65,108.71 C598.1 ; 72.65,108.71 72.77,108.58 C598.1 ; R584.1 C605.1 ; C598.1 72.65,107.69 v1(73.03,107.31) ; R587.1 C608.1
  BOTTOM w0.508: C604.2 R583.2 v1(190.38,46.99) 190.39,46.98 196.86,46.98 v1(200.03,43.81) R126.1 ; v1(175.38,116.72) C601.1 R578.1 v1(175.38,112.52) ; v1(132.72,113.67) R579.1 C602.1 ; R586.1 150.54,34.04 151.13,34.63 v1(151.13,34.92) 152.02,35.82 C607.1 ; C605.1 109.1,35.18 v1(109.86,35.94) 112.05,35.94 116.24,31.75 C606.1 R585.1 ; v1(180.97,169.54) R574.1 C597.2 184.3,168.28 186.38,170.36 197.71,170.36 198.12,170.77 ; R134.2 v1(198.88,25.28) ; v1(178.67,174.61) 177.29,175.99 C595.2 R572.1 ; 198.12,170.77 198.51,170.38 201.88,170.38 204.29,172.79 209.81,172.79 217.81,164.8 217.81,93.98 217.17,93.34 215.26,93.34 214,92.08 ; 198.12,170.77 R540.1 ; R582.2 184.27,31.11 C603.2 181.5,31.24 179.72,33.02 v1(171.33,33.02) C608.1 ; R597.2 v1(124.46,137.28)
VP+15V: length 389.9
  ART03 w1.016: v1(179.2,19.18) 179.2,26.67 185.36,32.84 185.36,35.73 189.1,39.47 190.6,39.47 v1(210.82,59.69) 211.05,59.92 211.05,81.51 214,84.45
  ART05 w0.508: v1(158.75,15.88) 155.57,19.05 143.26,19.05 v1(140.08,15.88) ; v1(211.46,94.61) 211.46,100.58 214.76,103.89 214.76,165.23 207.21,172.78 197.39,172.78 196.06,171.45 189.87,171.45 188.51,172.81 179.05,172.81 174.49,168.25 145.43,168.25 142.24,165.06 v1(142.24,152.4) 139.24,152.4 131.3,144.45 129.51,144.45 126.86,141.8 126.86,135.98 125.18,134.29 101.75,134.29 100.22,135.83 61.53,135.83 v1(59.05,133.35)
  BOTTOM w0.508: C1.1 143.5,154.17 R3.2 v1(142.24,152.4) ; R183.2 53.58,133.86 C158.1 55.24,133.14 55.8,132.58 C156.1 58.29,132.58 v1(59.05,133.35) ; v1(140.08,15.88) R184.2 138.55,16.12 C170.1 139.2,18.42 C173.1 ; 214,84.45 211.46,87 v1(211.46,94.61)
VP+15V_DCDCA: length 24.1
  ART05 w0.508: v1(113.55,42.02) 113.55,39.45 122.29,30.71 129.7,30.71 U19.7
  BOTTOM w0.508: R591.2 v1(113.55,42.02)
VP+15V_DCDCB: length 16.8
  ART05 w0.381: v1(156.21,41.02) 153.92,41.02 148.39,35.49 U20.7
  BOTTOM w0.508: R589.2 154.69,41.38 155.85,41.38 v1(156.21,41.02)
VP+15V_HF_PFC: length 44
  ART03 w0.508: v1(191.77,99.06) 191.77,101.96 176.19,117.54 163.76,117.54 v1(160.02,121.28)
  BOTTOM w0.508: R580.2 160.29,121.56 v1(160.02,121.28)
VP-5V: length 102.7
  ART03 w0.508: J3.19 218.64,89.97 218.64,64.34 208.78,54.48 208.78,37.85 v1(209.8,36.83) 209.8,31.04 202.87,24.1 197.64,24.1 v1(196.98,24.77) 193.42,28.32 v1(184.78,28.32)
  BOTTOM w0.381: R122.2 185.4,29.84 185.02,29.46 185.02,28.56 v1(184.78,28.32)
  BOTTOM w0.508: U3.4 196.22,26.67 195.7,26.16 C88.1 v1(196.98,24.77)
VPFC: length 258.2
  TOP w1.016: 170.71,139.76 C9.1 ; C9.1 176,139.76 ; C9.1 173.35,137.12 ; 191.52,137.24 C18.1 ; C18.1 188.87,139.89 ; C18.1 194.16,139.89 ; 154.94,137.12 C12.1 ; C12.1 157.58,139.76 ; C12.1 152.3,139.76
  ART02 w1.016: 180.04,46.35 CB6.1 ; CB6.1 184.81,46.35 ; CB6.1 182.43,48.74 ; 206.9,165.74 C16.1 204.26,168.39 ; C18.1 194.16,139.89 ; C18.1 191.52,137.24 ; C18.1 191.52,142.53 ; C18.1 188.87,139.89 ; 154.94,142.4 C12.1 157.58,139.76 ; 170.71,139.76 C9.1 ; C9.1 173.35,137.12 ; C9.1 173.35,142.4 ; C9.1 176,139.76 ; 53.27,126.5 D2.1 ; D2.1 55.65,128.89 ; D2.1 53.27,131.28 ; D2.1 50.88,128.89 ; C11.1 173.1,160.95 ; C11.1 170.46,158.3 ; C11.1 173.1,155.66 ; C11.1 175.74,158.3 ; 206.9,110.5 C13.1 ; C13.1 206.9,115.78 ; C13.1 204.26,113.14 ; C14.1 206.9,152.61 ; C14.1 206.9,147.33 ; C14.1 204.26,149.97 ; 154.53,155.78 C10.1 ; C10.1 151.89,158.43 ; C10.1 157.17,158.43 ; C10.1 154.53,161.07 ; 180.04,33.66 CB7.1 ; CB7.1 184.81,33.66 ; CB7.1 182.43,36.04 ; 188.87,158.3 C15.1 ; C15.1 194.16,158.3 ; C15.1 191.52,155.66 ; C15.1 191.52,160.95 ; C17.1 206.9,134.2 ; C17.1 206.9,128.91 ; C17.1 204.26,131.56
  ART03 w1.016: 152.3,139.76 C12.1 ; C12.1 154.94,142.4 ; C12.1 157.58,139.76 ; C12.1 154.94,137.12 ; C15.1 194.16,158.3 ; C15.1 188.87,158.3 ; C15.1 191.52,160.95 ; C15.1 191.52,155.66 ; 151.89,158.43 C10.1 ; C10.1 154.53,161.07 ; C10.1 154.53,155.78 ; C10.1 157.17,158.43 ; C16.1 209.54,168.39 ; C16.1 204.26,168.39 ; C16.1 206.9,171.03 ; C16.1 206.9,165.74 ; 173.35,137.12 C9.1 ; C9.1 173.35,142.4 ; C9.1 176,139.76 ; C9.1 170.71,139.76 ; C11.1 175.74,158.3 ; C11.1 173.1,155.66 ; C11.1 170.46,158.3 ; C11.1 173.1,160.95 ; 191.52,137.24 C18.1 ; C18.1 191.52,142.53 ; C18.1 194.16,139.89 ; C18.1 188.87,139.89 ; 204.26,131.56 C17.1 ; C17.1 206.9,128.91 ; C17.1 206.9,134.2 ; 204.26,149.97 C14.1 206.9,147.33 ; C13.1 206.9,115.78 ; C13.1 204.26,113.14 ; C13.1 206.9,110.5
  BOTTOM w0.508: R38.2 203.84,112.01 204.96,113.14 C13.1
  BOTTOM w1.016: 154.94,137.88 C12.1 ; C12.1 153.06,139.76 ; C12.1 156.82,139.76 ; C12.1 154.94,141.64 ; C9.1 173.35,141.64 ; C9.1 171.47,139.76 ; C9.1 173.35,137.88 ; C9.1 175.24,139.76 ; C18.1 193.4,139.89 ; C18.1 191.52,141.77 ; C18.1 191.52,138.01 ; C18.1 189.63,139.89
VPFC_LF+15V: length 18.9
  TOP w0.508: 77.49,134.77 77.49,127.49 80.46,124.52 83.25,124.52 v1(83.82,125.09)
  BOTTOM w0.508: C599.2 86.12,123.55 R576.2 84.45,124.46 v1(83.82,125.09)
VS+5V: length 227.8
  TOP w0.508: v1(85.09,34.67) 85.09,29.97 v1(85.72,29.33) C100.1 87.12,29.21 R139.2 ; v1(136.53,5.08) 132.08,5.08 131.68,4.68 U33.1
  ART03 w0.508: v1(136.53,5.08) 139.7,5.08 143.86,0.92 177.99,0.92 181.15,4.08 181.15,6.89 182.42,8.17 216.11,8.17 218.19,10.25 218.19,16.84 216.62,18.41 J4.7
  ART05 w0.508: v1(85.09,34.67) 83.3,36.46 65.93,36.46 v1(64.14,34.67) 62.55,36.26 46.03,36.26 v1(44.45,34.67) 43.21,35.91 24.86,35.91 v1(23.5,34.54) ; v1(120.65,7.62) 118.04,10.23 107.85,10.23 101.71,16.38 101.71,18.62 90.99,29.33 v1(85.72,29.33)
  BOTTOM w0.508: R600.1 v1(64.14,34.67) ; R599.1 v1(44.45,34.67) ; R598.1 v1(23.5,34.54) ; R601.1 v1(85.09,34.67)
VS+15V: length 95.2
  ART03 w0.508: J4.1 214.86,9.12 181.95,9.12 180.03,7.2 180.03,4.76 177.02,1.75 145.06,1.75 140.77,6.05 137.92,6.05 J8.4
  BOTTOM w1.016: 131.23,2.33 136.35,7.45 J8.4
  vias: v1(95.5,4.83) v1(95.5,3.68) v1(95.5,2.54) v1(107.57,4.83) v1(107.57,3.68) v1(107.57,2.54) v1(119.51,3.05) v1(119.51,1.78) v1(129.16,2.16)
VS+15V_DCDCA: length 88.7
  ART02 w0.508: v1(28.57,41.66) 26.04,41.66 22.61,38.22 22.61,24.53 26.54,20.6 53.06,20.6 56.13,17.53 84.64,17.53 U22.7
  BOTTOM w0.508: R592.2 27.31,42.02 28.22,42.02 v1(28.57,41.66)
VS+15V_DCDCB: length 70.4
  ART02 w0.508: U23.7 92.76,23.25 92.76,51.81 90.56,54.02 74.71,54.02 72.47,51.78 72.47,44.92 v1(69.22,41.66)
  BOTTOM w0.508: R594.2 67.95,42.02 68.86,42.02 v1(69.22,41.66)
VSLOW+15V: length 76.5
  ART05 w0.508: v1(49.53,41.66) 50.55,40.64 v1(90.81,40.64) 97.09,34.36 97.09,27.88 106.55,18.41 U24.7
  BOTTOM w0.508: v1(49.53,41.66) 49.17,42.02 48.27,42.02 R593.2 ; R595.2 v1(90.81,40.64)
N16148248: length 2.6
  BOTTOM w0.508: R84.2 35.93,7.75 R89.1
N16148380: length 9.4
  BOTTOM w0.508: R96.1 R93.2 42.99,16.64 C58.2
N16148534: length 2.7
  BOTTOM w0.508: R90.2 40.9,13.47 R93.1
N16148538: length 2.7
  BOTTOM w0.508: R90.1 38.36,10.29 R89.2
N16148540: length 2.7
  BOTTOM w0.508: R101.1 39.11,22.36 R96.2
N16148544: length 2.7
  BOTTOM w0.508: R107.1 34.03,28.07 R102.2
N16320789: length 2.6
  BOTTOM w0.508: R101.2 36.46,25.53 R102.1
N16599678: length 3.3
  BOTTOM w0.508: R33.2 94.74,119.39 94.09,118.75 D48.2
N16600162: length 2.4
  BOTTOM w0.508: D47.2 70.1,120.02 70.1,120.02 70.61,120.52 R54.2
N16765027: length 3.9
  TOP w0.508: U10.1 R140.1 C102.2
N16765075: length 3.7
  TOP w0.508: R140.2 106.93,29.33 C101.1 110.24,29.33 R545.2
N16767690: length 3.9
  TOP w0.508: C103.2 R139.1 U10.16
N16833658: length 2.6
  TOP w0.508: R141.1 U10.2
N16833676: length 2.6
  TOP w0.508: U10.3 R143.1
N16833742: length 2.6
  TOP w0.508: U10.4 R145.1
N16833760: length 2.6
  TOP w0.508: R147.1 U10.5
N16833940: length 2.6
  TOP w0.508: U10.15 R142.1
N16833942: length 2.6
  TOP w0.508: U10.14 R144.1
N16834016: length 2.6
  TOP w0.508: U10.13 R146.1
N16834018: length 2.6
  TOP w0.508: U10.12 R148.1
N17093919: length 2.5
  BOTTOM w0.508: R3.1 R2.2
N17093922: length 2.5
  BOTTOM w0.508: R2.1 R1.2
N17244938: length 2.3
  BOTTOM w0.508: R15.2 R16.1
N17244999: length 2.3
  BOTTOM w0.508: R14.2 R15.1
N17245029: length 2.3
  BOTTOM w0.508: R20.2 R21.1
N17245032: length 2.3
  BOTTOM w0.508: R21.2 R22.1
N17252696: length 4
  BOTTOM w0.381: U103.2 C30.1
  BOTTOM w0.508: R62.1 C30.1
N17252758: length 4
  BOTTOM w0.508: U103.1 C29.2 R573.2
N17252921: length 4
  BOTTOM w0.381: U103.8 177.22,170.81 177.25,170.79
  BOTTOM w0.508: R574.2 C27.2 177.28,170.81 177.25,170.79
N17253061: length 2.8
  BOTTOM w0.381: U103.7 R63.2
N17253066: length 2.8
  BOTTOM w0.381: U103.6 R64.2
N17253305: length 6.9
  BOTTOM w0.508: R63.1 180.47,172.09 181.23,172.84 C28.2 R537.1 186.21,172.84 U2.5
N17253318: length 7
  BOTTOM w0.508: R64.1 180.72,174.25 R65.2 C31.1 184.15,174.25 185.05,174.25 185.31,173.99 U2.6
N17253751: length 8.2
  BOTTOM w0.508: U2.8 185.96,176.53 185.33,177.16 C26.2 184.27,177.93 183.77,178.44 180.85,178.44 180.46,178.05 R572.2
N17259772: length 2.3
  BOTTOM w0.508: R37.2 210.44,121.15 R30.1
N17259775: length 2.3
  BOTTOM w0.508: R37.1 213.24,116.59 R39.2
N17259778: length 2.2
  BOTTOM w0.508: R43.2 216.03,114.56 R39.1
N17259967: length 2.3
  BOTTOM w0.508: R40.2 204.47,106.55 R38.1
N17259969: length 3.5
  BOTTOM w0.508: R45.2 208.91,104.65 208.41,105.16 R40.1
N17266948: length 67.7
  ART03 w0.508: v1(138.43,2.54) 134.11,2.54 128.78,7.88 124.78,7.88 122.41,10.25 80.56,10.25 v1(79.88,10.93)
  BOTTOM w0.508: R114.2 v1(79.88,10.93) ; v1(138.43,2.54) 139.06,3.17 R115.1
N17266951: length 2.3
  BOTTOM w0.508: R118.1 R115.2
N17268549: length 7.2
  BOTTOM w0.508: R116.2 C82.2 R117.1 188.19,26.04 188.7,26.55 C83.2 189.94,26.55 190.06,26.67 U3.5
N17268684: length 13.1
  BOTTOM w0.508: 192.68,29.21 193.36,29.89 D8.1 ; 192.68,29.21 U3.7 ; 192.68,29.21 192.79,29.11 192.79,25.78 191.77,24.77 R116.1
N17268693: length 6.9
  BOTTOM w0.508: U3.6 190.39,27.94 190.26,28.06 C83.1 188.95,28.06 188.19,27.3 R123.1 C87.2 R122.1
N17268930: length 4.3
  BOTTOM w0.508: U3.8 190.78,30.48 190.02,31.24 C248.2 187.57,31.24 R582.1
N17268988: length 10.2
  BOTTOM w0.508: R127.2 C92.1 R129.2 201.11,25.4 200.98,25.52 200.98,26.5 200.69,26.79 R134.1 C97.2 199.32,28.45 198.81,27.94 U3.3
N17269030: length 6.4
  BOTTOM w0.508: U3.2 198.58,29.21 199.34,29.97 C97.1 200.6,29.97 201.11,30.48 C99.2 R138.1
N17269076: length 17.7
  ART03 w0.508: v1(198.75,30.48) 204.41,30.48 v1(204.43,30.5)
  BOTTOM w0.508: R127.1 204.53,27.94 205.36,28.77 205.36,29.67 204.55,30.48 204.45,30.48 v1(204.43,30.5) ; D8.2 195.26,31.03 195.88,30.4 197.13,30.4 U3.1 v1(198.75,30.48)
N17269867: length 3.8
  BOTTOM w0.508: C89.1 186.54,37.59 185.93,38.2 R121.2 R120.1
N17269877: length 7.3
  BOTTOM w0.508: R119.2 C90.1 187.96,38.23 187.45,38.74 R121.1 188.15,39.37 188.27,39.25 C91.1 189.94,39.25 190.06,39.37 U4.5
N17270011: length 8
  BOTTOM w0.508: C94.1 R132.1 187.2,42.16 C96.1 R130.1 188.15,40.64 188.27,40.76 C91.2 189.94,40.76 190.06,40.64 U4.6
N17270029: length 1.7
  BOTTOM w0.508: R135.1 R130.2
N17270191: length 5.5
  BOTTOM w0.508: U4.8 191.46,43.23 192.87,43.23 193.55,43.91 C84.2 192.92,45.72 R583.1
N17272262: length 6.5
  BOTTOM w0.381: U9.1 206.69,41.63 206.47,41.85 204.4,41.85 203.83,42.42 R136.2
  BOTTOM w0.508: R136.2 202.26,42.42 202.01,42.67 R128.1
N17288635: length 5.7
  BOTTOM w0.508: U5.1 85.09,111.25 84.45,110.62 R251.2 C35.1 R67.1
N17288650: length 5.7
  BOTTOM w0.508: R68.1 C36.1 R250.2 83.19,110.62 83.82,111.25 U5.2
N17289174: length 15.3
  ART05 w0.508: v1(76.2,111.12) 77.78,112.7 80.97,112.7 v1(82.55,111.12)
  BOTTOM w0.508: U5.8 v1(76.2,111.12) 76.2,110.98 76.83,110.35 C39.1 C40.1 74.17,109.98 R575.2 ; U5.3 v1(82.55,111.12)
N17289191: length 3.2
  BOTTOM w0.508: R69.1 79.38,110.91 80.01,111.54 U5.5
N17289200: length 3.2
  BOTTOM w0.508: R70.1 78.11,111.12 78.74,111.76 U5.6
N17289613: length 7.2
  BOTTOM w0.508: C497.1 82.55,121.54 C33.1 83.08,121.56 R576.1 84.45,120.65 85.09,120.02 U5.16
N17289747: length 10.1
  BOTTOM w0.508: R577.1 77.83,115.93 78.74,116.84 U5.11 78.74,119.91 78.36,120.29 C38.1
N17291315: length 9.1
  BOTTOM w0.508: U106.5 120.42,121.31 C46.1 122.3,124.05 122.78,124.52 124.67,124.52 R581.1
N17329322: length 5.4
  BOTTOM w0.381: C245.1 210.44,40.97 209.58,40.11 209.58,38.03 209.83,37.79 U30.5
N17329326: length 2.7
  BOTTOM w0.381: C245.2 208.66,40.83 208.9,40.59 208.9,39.95 208.63,39.68 U30.3
N17381506: length 2.5
  BOTTOM w0.508: R216.1 162.69,126.74 R27.2
N17381677: length 2.5
  BOTTOM w0.508: R51.2 119.51,126.74 R219.1
N17454032: length 7.9
  BOTTOM w0.508: U21.1 171.57,13.97 C183.1 172.73,13.84 C184.1 174.12,13.97 R186.1
N17461429: length 12.6
  TOP w0.508: U34.5 102.48,134.62 99.94,137.16 U34.2 97.84,137.16 96.57,138.43 R245.2 C281.1 R244.1
N17461431: length 5.8
  TOP w0.508: U34.3 97.59,135.89 96.32,137.16 R240.1 C278.2 R243.1
N17461459: length 6.9
  TOP w0.508: U34.6 v1(102.87,135.89)
  BOTTOM w0.508: R242.1 R241.2 C280.1 103.41,134.62 102.87,135.16 v1(102.87,135.89)
N17461635: length 6.7
  TOP w0.508: v1(103.12,138.68) 103.38,138.43 U34.8 106.56,138.43 R596.2
  BOTTOM w0.508: R239.2 102.36,139.58 103.12,138.81 v1(103.12,138.68) 103.38,138.43 C279.1
N17461650: length 10.4
  TOP w0.508: U34.1 99.95,138.43 v1(100.2,138.68) 101.09,137.79 102.49,137.79 103.12,137.16 U34.7
  BOTTOM w0.508: Q60.1 100.65,138.24 v1(100.2,138.68) 100.84,139.32 R239.1 C282.2
N17461720: length 9.4
  TOP w0.508: v1(107.57,140.46) 105.14,140.46 104.5,139.83 103.12,139.83 v1(101.98,138.68)
  BOTTOM w0.508: U35.3 109.03,140.46 v1(107.57,140.46) ; Q60.2 102.55,138.12 v1(101.98,138.68)
N17461740: length 3.9
  BOTTOM w0.508: U35.2 109.16,137.92 108.14,138.95 107.65,138.95 106.89,139.7 R246.2
N17461769: length 2.7
  BOTTOM w0.508: U35.7 118.68,137.28 R247.1
N17461771: length 5.2
  BOTTOM w0.508: R597.1 C612.1 R247.2 118.68,135.77 U35.8
N17461781: length 190.4
  ART05 w0.508: v1(216.53,104.14) 216.79,104.39 216.79,166.88 207.56,176.1 188.9,176.1 188.1,175.3 180.93,175.3 180,176.23 176.18,176.23 170.86,170.91 143.4,170.91 137.76,165.27 137.76,163.23 139.7,161.29 139.7,155.65 130.41,146.36 128.25,146.36 122.22,140.34 v1(120.02,140.34)
  BOTTOM w0.508: R248.2 v1(216.53,104.14) ; U35.6 v1(120.02,140.34)
N17577735: length 3.4
  BOTTOM w0.508: R539.2 199.39,174.5 R538.1 199.87,174.98 U55.1
N17746491: length 7.8
  BOTTOM w0.508: U104.1 168.28,113.54 168.78,113.03 170.34,113.03 170.81,113.5 C530.1 C531.1 173.74,114.18 R578.2
