# Allegro board HD_6k6W_OBC_MAIN_BOARD-v3_pcb_layout.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
N17747250: length 6.1
  BOTTOM w0.508: U104.2 167,113 166.49,112.49 C43.1 R72.1 168.15,110.49 R71.2
N17749975: length 7.1
  BOTTOM w0.508: U106.1 124.21,114.38 124.21,113.52 124.57,113.16 125.72,113.16 126.1,113.54 C48.1 C47.1 128.39,113.67 R579.2
N17750019: length 6
  BOTTOM w0.508: U106.2 122.96,113.39 123.83,112.52 R74.2 122.17,111.88 C44.1 R73.1
N17751858: length 7.7
  BOTTOM w0.508: C41.1 163.83,123.19 163.19,122.56 R580.1 ; C41.1 164.84,121.91 164.47,121.53 U104.5 ; C41.1 164.84,124.33 164.47,124.71 C498.1
N17785545: length 4.8
  BOTTOM w0.508: R584.2 C533.1 C532.1 106.05,37.34 U108.1
N17785579: length 5.6
  BOTTOM w0.508: C544.1 R550.1 R551.2 104.85,37.42 104.85,39.32 U108.2
N17785699: length 7.1
  BOTTOM w0.508: U107.1 127,37.34 C540.1 C541.1 126.88,34.67 126.87,34.67 R585.2
N17785727: length 5.5
  BOTTOM w0.508: C543.1 R548.1 R549.2 125.73,37.34 U107.2
N17785767: length 13.8
  BOTTOM w0.508: R591.1 112.15,40.26 C536.1 109.59,40.26 108.58,41.26 C542.1 103.53,42.67 102.23,43.97 U108.5
N17785926: length 13.7
  BOTTOM w0.508: U107.5 123.19,43.97 124.2,42.96 128.99,42.96 129.29,42.67 ; C545.1 131.72,43.07 R590.1 130.07,41.27 129.54,41.81 129.54,42.67 129.29,42.67 ; 129.29,42.67 C549.1
N17788175: length 4.8
  BOTTOM w0.508: U110.1 148.34,36.7 C550.1 C551.1 R586.2
N17788213: length 5.5
  BOTTOM w0.508: C558.1 R554.1 R555.2 147.07,36.7 U110.2
N17788281: length 4.8
  BOTTOM w0.508: R587.2 C555.1 C554.1 168.28,36.95 U109.1
N17788301: length 5.5
  BOTTOM w0.508: U109.2 167,36.95 R553.2 R552.1 C557.1
N17788345: length 13.8
  BOTTOM w0.508: U110.5 144.53,43.33 145.82,42.04 C556.1 150.88,40.63 151.88,39.63 C553.1 154.45,39.63 R589.1
N17788478: length 14
  BOTTOM w0.508: U109.5 164.47,43.59 165.76,42.29 C563.1 170.81,40.64 171.71,39.75 C559.1 174.52,39.75 R588.1
N17790300: length 4.9
  BOTTOM w0.508: U112.1 20.95,37.34 C564.1 C565.1 R598.2
N17790352: length 5.7
  BOTTOM w0.508: C572.1 R558.1 17.91,36.57 R559.2 19.68,37.21 19.68,39.4
N17790406: length 4.8
  BOTTOM w0.508: R599.2 C569.1 C568.1 41.91,37.34 U111.1
N17790440: length 5.5
  BOTTOM w0.508: C571.1 R556.1 R557.2 40.64,37.34 U111.2
N17790484: length 13.8
  BOTTOM w0.508: R592.1 27.06,40.26 C567.1 24.5,40.26 23.5,41.26 C570.1 18.44,42.67 17.14,43.97 U112.5
N17790617: length 14.1
  BOTTOM w0.508: U111.5 38.1,43.97 39.4,42.67 C577.1 44.45,40.86 45.31,40 C573.1 46.37,40.02 R593.1
N17792648: length 4.8
  BOTTOM w0.508: R600.2 C579.1 C578.1 61.59,37.34 U114.1
N17792696: length 5.5
  BOTTOM w0.508: U114.2 60.33,37.34 R562.2 R563.1 C586.1
N17792742: length 4.8
  BOTTOM w0.508: U113.1 82.55,37.34 C582.1 C583.1 R601.2
N17792776: length 5.5
  BOTTOM w0.508: C585.1 R560.1 R561.2 81.28,37.34 U113.2
N17792812: length 13.8
  BOTTOM w0.508: R594.1 67.7,40.26 C581.1 65.14,40.26 64.14,41.26 C584.1 59.08,42.67 57.78,43.97 U114.5
N17792937: length 12.4
  BOTTOM w0.508: R595.1 87.27,42.44 C587.1 87.25,42.67 C591.1 80.04,42.67 78.74,43.97 U113.5
N17799215: length 2.2
  BOTTOM w0.508: R565.1 D58.1
N17799359: length 2.5
  BOTTOM w0.508: R567.1 157.87,47.5 D60.1
N17812200: length 9.8
  BOTTOM w0.381: D61.3 91.44,73.07 CT12.1
N17812202: length 6
  BOTTOM w0.381: CT11.1 86.36,68.44 D62.3
N17820985: length 2.5
  BOTTOM w0.508: R571.2 53.08,7.49 R569.1
N17820987: length 2.5
  BOTTOM w0.508: R570.1 56.01,5.34 R569.2
N17880901: length 2.5
  BOTTOM w0.508: R564.2 95.64,47.63 D57.1
N17880973: length 2.8
  BOTTOM w0.508: R566.2 116.59,47 D59.1
N165538091: length 9.9
  TOP w1.016: RV1.1 142.29,149.17 ; RV1.1 140.64,147.52 ; RV1.1 138.99,149.17 ; RV2.2 141.28,143.22 ; RV2.2 139.62,141.57 ; RV2.2 142.93,141.57

## Copper pours and planes (outline as drawn)
+5V_A on TOP (solid shape): 90.5,141.46 90.5,139.6 91.25,138.85 94.64,138.85 94.9,138.59 94.9,136.93 94.65,136.69 91.77,136.69 91.17,137.29 94.49,137.29 94.49,138.3 93.6,138.3 93.6,137.29 91.17,137.29 90.33,138.13 85.06,138.13 81.55,134.62 80.72,134.62 80.56,134.78 80.56,136.13 80.64,136.22 81.28,136.22 82.26,137.2 82.26,137.79 83.57,137.79 83.57,138.43 82.8,138.43 82.8,137.79 82.26,137.79 82.26,138.48 83.26,139.49 83.26,141.39 83.57,141.7 90.26,141.7
-3V_PSW1 on BOTTOM (solid shape): 211.38,72.62 211.38,70.46 210.83,69.91 200.52,69.91 200.15,70.28 200.15,70.99 204.34,70.99 204.34,71.63 203.71,71.63 203.71,70.99 200.15,70.99 200.15,72.31 200.33,72.49 203,72.49 203.4,72.09 205.36,72.09 206.25,72.97 211.02,72.97
-3V_PSW2 on BOTTOM (solid shape): 203.48,93.17 203.48,88.89 203.02,88.42 192.33,88.42 192.02,88.73 192.02,90.68 200.15,90.68 200.15,91.31 199.39,91.31 199.39,90.68 192.02,90.68 192.02,91.06 192.33,91.36 198.4,91.36 198.5,91.47 198.5,91.49 198.78,91.77 200.3,91.77 200.63,92.1 200.63,93.24 200.94,93.55 203.1,93.55
-3V_PSW3 on BOTTOM (solid shape): 68.07,142.7 68.07,141.1 67.69,140.72 67.69,140.72 67.61,140.64 67.61,139.4 67.36,139.15 66.76,139.15 66.04,138.43 66.03,138.43 65.96,138.35 65.96,133.52 65.79,133.35 63.37,133.35 63.12,133.6 63.12,139.7 67.18,139.7 67.18,140.46 66.42,140.46 66.42,139.7 63.12,139.7 63.12,142.66 63.42,142.96 67.81,142.96
-3V_PSW4 on BOTTOM (solid shape): 170.41,24.41 172.52,24.41 173.07,23.85 173.07,23.07 173.36,22.78 175.16,22.78 176.07,21.88 178.26,21.88 178.46,21.68 178.46,20.22 178.27,20.04 168.4,20.04 168.12,20.32 168.12,23.24 172.09,23.24 172.09,24 171.32,24 171.32,23.24 168.12,23.24 168.12,24.43 168.5,24.82 170,24.82
-3V_PSW5 on BOTTOM (solid shape): 134.06,26.6 138.7,26.6 139.04,26.26 139.04,24.11 138.61,23.68 129.22,23.68 128.92,23.98 128.92,25.91 133.35,25.91 133.35,26.54 132.72,26.54 132.72,25.91 128.92,25.91 128.92,26.72 129.23,27.02 133.65,27.02
-3V_PSW7 on BOTTOM (solid shape): 149.57,25.73 151.32,25.73 151.33,25.72 152.13,25.72 152.54,25.31 153.89,25.31 153.91,25.33 155.29,25.33 155.29,25.33 155.78,24.84 155.78,24.24 156.2,23.82 157.71,23.82 157.9,23.62 157.9,22.89 157.68,22.67 147.73,22.67 147.34,23.06 147.34,25.89 147.8,26.35 148.94,26.35
-3V_PSW9 on BOTTOM (solid shape): 86.94,13.69 91.99,13.69 92.41,13.27 94.07,13.27 94.25,13.09 94.25,10.7 93.9,10.35 85.16,10.35 84.78,10.73 84.78,12.45 88.27,12.45 88.27,13.21 87.63,13.21 87.63,12.45 84.78,12.45 84.78,13.7 85.27,14.19 86.43,14.19
-3V_PSW10 on BOTTOM (solid shape): 111.07,13.69 116.12,13.69 116.54,13.27 118.83,13.27 119.09,13 119.09,10.45 118.99,10.35 109.17,10.35 108.91,10.61 108.91,12.45 113.03,12.45 113.03,13.21 112.39,13.21 112.39,12.45 108.91,12.45 108.91,13.84 109.26,14.19 110.56,14.19
-3V_PSW11 on BOTTOM (solid shape): 99,13.69 104.06,13.69 104.48,13.27 106.12,13.27 106.28,13.12 106.28,10.58 106.04,10.35 97.14,10.35 96.87,10.61 96.87,12.57 100.97,12.57 100.97,13.21 100.33,13.21 100.33,12.57 96.87,12.57 96.87,13.88 97.18,14.19 98.5,14.19
AGND on TOP (solid shape): 207.89,22.7 207.89,15.69 206.99,14.79 187.96,14.79 187.96,14.8 186.25,14.8 185.87,14.42 185.26,14.42 184.91,14.76 182.46,14.76 182.24,14.99 185.42,14.99 185.42,15.49 184.91,15.49 184.91,14.99 182.24,14.99 182.15,15.08 182.15,23.25 182.7,23.8 206.79,23.8
AGND on BOTTOM (solid shape): 132.4,167.03 132.4,162.06 132.2,161.86 130.81,161.86 130.68,162 130.68,167.22 130.81,167.35 132.08,167.35
AGND on BOTTOM (solid shape): 177.02,18.35 177.02,16.72 177.53,16.21 177.53,15.66 177.19,15.33 175.94,15.33 175.35,15.92 172.77,15.92 172.39,15.54 168.74,15.54 168.47,15.81 168.47,16 172.09,16 172.09,16.76 171.45,16.76 171.45,16 168.47,16 168.47,17.99 169.06,18.59 176.79,18.59
AGND on BOTTOM (solid shape): 60.19,142.77 60.19,135.22 59.66,134.69 56.29,134.69 56.07,134.91 54.91,134.91 54.79,135.03 54.79,135.78 54.97,135.97 56.13,135.97 57.2,137.03 57.2,138.81 57.46,139.08 57.46,139.7 58.67,139.7 58.67,140.34 57.91,140.34 57.91,139.7 57.46,139.7 57.46,140.28 58.39,141.2 58.42,141.2 58.42,142.74 58.55,142.87 60.08,142.87
AGND on BOTTOM (solid shape): 212.68,39.5 212.68,32.83 212.51,32.66 208.26,32.66 205.74,35.18 204.01,35.18 203.63,35.56 203.63,37.01 203.75,37.13 205.15,37.13 205.17,37.14 206.95,37.14 207.39,36.7 207.39,34.99 207.77,34.61 211.58,34.61 211.89,34.92 211.89,38.28 211.35,38.82 210.21,38.82 210.07,38.95 210.07,39.95 210.23,40.11 212.07,40.11
AGND on BOTTOM (solid shape): 206.29,87.48 206.29,85.36 206.66,84.99 206.66,83.99 206.46,83.78 200.13,83.78 199.81,84.11 197.6,84.11 197.26,84.45 206.12,84.45 206.12,85.09 205.49,85.09 205.49,84.45 197.26,84.45 197.21,84.5 194.71,84.5 194.54,84.66 194.54,84.71 199.39,84.71 199.39,85.34 198.75,85.34 198.75,84.71 194.54,84.71 194.54,86.87 194.75,87.08 203.47,87.08 204.23,87.84 205.93,87.84
AGND on BOTTOM (solid shape): 208.81,66.84 208.81,63.82 209.25,63.38 209.25,62.39 208.99,62.12 207.49,62.12 207.15,62.47 207.15,62.87 208.66,62.87 208.66,63.5 208.15,63.5 208.15,62.87 207.15,62.87 207.15,63.39 206.94,63.6 204.81,63.6 204.39,63.18 200.44,63.18 200.01,63.61 200.01,63.63 203.84,63.63 203.84,64.52 203.07,64.52 203.07,63.63 200.01,63.63 200.01,66.86 200.32,67.18 208.46,67.18
AGND on BOTTOM (solid shape): 155.5,20.1 155.5,17.98 155.91,17.58 155.91,16.67 155.76,16.51 153.96,16.51 153.77,16.7 153.77,17.14 155.32,17.14 155.32,17.65 154.69,17.65 154.69,17.14 153.77,17.14 153.77,17.61 153.54,17.84 151.37,17.84 150.96,17.43 149.78,17.43 149.78,17.43 149.29,17.43 148.81,16.95 147.91,16.95 147.55,17.32 147.55,18.03 150.5,18.03 150.5,18.67 149.73,18.67 149.73,18.03 147.55,18.03 147.55,19.96 147.87,20.28 155.33,20.28
AGND on BOTTOM (solid shape): 137.09,20.73 137.09,18.62 137.5,18.21 137.5,17.3 137.34,17.15 135.55,17.15 135.36,17.34 135.36,17.78 137.03,17.78 137.03,18.41 136.27,18.41 136.27,17.78 135.36,17.78 135.36,18.25 135.13,18.47 132.95,18.47 132.55,18.07 131.02,18.07 130.53,17.57 129.36,17.57 128.87,18.07 128.87,18.54 132.08,18.54 132.08,19.3 131.32,19.3 131.32,18.54 128.87,18.54 128.87,19.54 128.87,19.55 128.87,20.45 129.33,20.91 136.91,20.91
AGND on BOTTOM (solid shape): 120.13,112.92 120.13,112.5 119.73,112.1 119.73,109.68 122.65,106.77 122.65,105.37 122.74,104.02 123.98,103.46 137.46,103.46 140.34,100.59 140.34,95.25 150.43,85.16 165.17,85.16 168.28,88.27 168.28,99.06 163.83,103.5 163.83,109.09 164.47,109.73 167.89,109.73 168.28,109.35 168.28,108.6 169.11,107.77 170.8,107.77 171.49,108.46 178.41,108.46 180.63,106.23 180.63,82.84 179.71,81.92 144.78,81.92 131.62,95.07 118.68,95.07 118.67,95.08 111.41,95.08 101.87,104.63 75.18,104.63 74.56,105.24 74.56,107.33 74.87,107.64 82.21,107.64 82.43,107.42 82.43,106.69 82.7,106.43 85.03,106.43 85.3,106.7 85.3,107.4 85.49,107.58 87.85,107.58 88.61,108.34 88.61,111.02 89.27,111.68 105.87,111.68 108.91,108.64 116.1,108.64 118.06,110.6 118.06,112.74 118.5,113.18 119.87,113.18
AGND on ART02 (solid shape): outline of 5654 points within 99.22,0.75 219.07,178.93
AGND on ART03 (solid shape): outline of 1678 points within 163.86,63.35 219,116.48
AGND on GND04 (solid shape): outline of 3227 points within 99.28,2.36 208.2,47.28
AGND on ART05 (solid shape): 201.26,17.53 201.26,16.21 197.82,12.76 182.53,12.76 181.84,13.46 181.84,16.36 183.41,17.93 200.86,17.93
AGND on ART05 (solid shape): 131.23,166.95 131.23,165.11 130.78,164.67 84.84,164.67 84.79,164.62 84.79,164.61 82.15,161.98 79.99,161.98 74.35,156.35 74.35,149.06 71.77,146.48 68.27,146.48 60.67,138.88 59.12,138.88 58.7,139.3 58.7,140.34 61.43,141.52 59.21,143.5 59.21,144 65.75,150.54 69.65,150.54 71.73,152.62 71.73,160.16 75.66,164.1 81.36,164.1 83.58,166.32 125.8,166.32 126.69,167.22 130.96,167.22
AGND on ART05 (solid shape): outline of 2797 points within 75.05,24.23 218.94,113.97
AGND_N on TOP (solid shape): 81.84,141.74 81.84,139.31 81.61,139.09 81.61,137.89 81.63,137.87 81.63,137.24 81.02,136.64 80.18,136.64 79.76,136.21 79.76,134.87 80.39,134.24 80.39,130.94 80.14,130.68 78.61,130.68 78.36,130.94 78.36,134.11 78.99,134.75 78.99,136.3 78.47,136.82 78.47,137.79 81.15,137.79 81.15,138.43 80.39,138.43 80.39,137.79 79.63,137.79 79.63,138.43 78.87,138.43 78.87,137.79 78.47,137.79 78.47,139.2 78.19,139.48 78.19,141.63 78.49,141.92 81.65,141.92
AGND_N on BOTTOM (solid shape): 68.75,130.18 68.75,127.53 67.54,126.33 67.54,124.76 67.36,124.58 66.01,124.58 65.76,124.82 65.76,130.29 66.21,130.73 68.19,130.73
AGND_N on BOTTOM (solid shape): 70.87,142.62 70.87,140.84 71.37,140.34 71.37,138.56 70.99,138.18 70.99,133.77 70.58,133.36 67.75,133.36 67.44,133.67 67.44,135.47 67.66,135.69 67.66,138.52 68.33,139.19 68.33,139.7 70.99,139.7 70.99,140.34 70.23,140.34 70.23,139.7 69.47,139.7 69.47,140.34 68.71,140.34 68.71,139.7 68.33,139.7 68.33,140.37 68.96,141 68.96,142.62 69.22,142.88 70.61,142.88
AGND_N on BOTTOM (solid shape): 97.92,136.78 97.92,133.06 97.64,132.79 87.27,132.79 86.3,131.82 86.3,126.02 86.44,125.89 86.56,125.89 86.57,125.9 87.37,125.9 87.96,125.3 87.96,123.52 88.39,123.09 91.72,123.09 92.38,122.43 93.49,122.43 93.59,122.32 93.59,120.36 93.41,120.18 88.02,120.18 87.56,119.72 86.78,119.72 86.66,119.84 86.66,120.54 87.2,121.07 87.2,123.83 86.82,124.21 85.57,124.21 84,125.78 83.1,125.78 82.8,125.48 81.08,125.48 77.09,129.46 77.09,136.91 77.34,137.16 97.54,137.16
AGND_N on ART03 (solid shape): outline of 1575 points within 33.43,123.92 109.6,146.54
P6.5V on TOP (solid shape): 186.27,13.4 188.86,13.4 188.96,13.51 190.96,13.51 191.14,13.33 191.14,10.67 190.83,10.35 180.62,10.35 179.46,9.18 160.57,9.18 159.86,8.47 159.86,6.87 160.52,6.21 161.98,6.21 162.55,5.64 162.55,4.16 161.87,3.48 159.11,3.48 158.19,4.4 158.19,10.9 158.96,11.67 178.46,11.67 179.36,12.57 185.42,12.57 185.42,13.21 184.91,13.21 184.91,12.57 179.36,12.57 180.17,13.39 184.69,13.39 184.7,13.38 185.09,13.77 185.9,13.77
PGND on TOP (solid shape): 141.34,136.97 141.34,133.34 140.77,132.78 131.8,132.78 130.99,131.97 129.68,131.97 129.3,131.59 129.3,129.93 129.3,129.92 129.3,127.18 129.02,126.89 126.97,126.89 126.42,127.44 126.42,130.62 126.42,130.62 126.42,132.14 131.19,136.9 133.61,136.9 134.34,137.63 140.68,137.63
PGND on TOP (solid shape): outline of 2407 points within 149.78,32.38 215.9,169.34
PGND on BOTTOM (solid shape): 105.98,130.52 105.98,125.94 106.73,125.2 107.12,125.2 107.75,124.57 109.84,124.57 110.11,124.29 110.11,122.29 109.94,122.13 106.13,122.13 105.94,122.31 105.94,123.46 105.7,123.7 104.2,123.7 104.18,123.68 102.71,123.68 102.34,124.05 102.34,130.52 102.62,130.8 105.7,130.8
PGND on BOTTOM (solid shape): 63.24,130.41 63.24,123.9 64.01,123.13 69.18,123.13 69.47,122.84 69.47,121.08 69.11,120.72 69.1,120.73 68.52,120.73 68.51,120.72 64.73,120.72 63.76,119.76 62.72,119.76 62.72,119.7 61.45,118.43 61.45,114.11 61.07,113.73 59.93,113.73 59.46,114.2 59.46,119.62 60.11,120.27 63.37,120.27 63.37,120.9 62.87,120.9 62.87,120.27 60.11,120.27 61.5,121.66 61.5,126.72 61.16,127.07 60.65,127.07 60.12,126.53 60.12,122.4 51.45,113.73 28.2,113.73 25.4,116.53 25.4,129.54 26.67,130.81 29.77,130.81 31.04,129.54 31.04,126.94 33.45,124.53 54.93,124.53 61.25,130.84 62.8,130.84
PGND on BOTTOM (solid shape): outline of 1048 points within 125.61,53.64 214.04,168.19
PGND on GND04 (solid shape): outline of 11265 points within 24.13,28.42 219.16,169.64
PGND on ART05 (solid shape): outline of 2014 points within 101.41,105.94 213.52,167.51
SGND on TOP (solid shape): 130.02,3.56 131.35,3.56 132.19,4.41 135.14,4.41 135.35,4.21 135.35,2.26 135.21,2.13 131.86,2.13 131.22,2.77 129.7,2.77 129.03,3.44 125.93,3.44 125.66,3.17 125.66,0.91 125.38,0.63 121.67,0.63 121.31,1 121.31,4.42 121.89,5 128.58,5
SGND on TOP (solid shape): outline of 372 points within 212.09,12.06 218.19,22.23
SGND on BOTTOM (solid shape): 126.02,2.82 126.02,0.89 125.78,0.65 121.8,0.65 121.55,0.9 121.55,2.96 121.8,3.2 125.64,3.2
SGND on BOTTOM (solid shape): 92.64,7.4 92.64,5.28 93.05,4.88 93.05,3.97 92.89,3.81 91.1,3.81 90.91,4 90.91,4.45 92.58,4.45 92.58,4.95 91.95,4.95 91.95,4.45 90.91,4.45 90.91,4.91 90.68,5.14 88.5,5.14 88.1,4.73 85.14,4.73 84.84,5.04 84.84,5.21 87.63,5.21 87.63,5.97 87,5.97 87,5.21 84.84,5.21 84.84,7.32 85.09,7.58 92.46,7.58
SGND on BOTTOM (solid shape): 104.7,7.4 104.7,5.28 105.11,4.88 105.11,3.97 104.96,3.81 103.16,3.81 102.97,4 102.97,4.45 104.52,4.45 104.52,5.08 104.01,5.08 104.01,4.45 102.97,4.45 102.97,4.91 102.74,5.14 100.57,5.14 100.16,4.73 96.7,4.73 96.48,4.95 96.48,5.21 99.69,5.21 99.69,5.97 99.06,5.97 99.06,5.21 96.48,5.21 96.48,7.37 96.68,7.58 104.53,7.58
SGND on BOTTOM (solid shape): 116.77,7.4 116.77,5.28 117.18,4.88 117.18,3.97 117.02,3.81 115.23,3.81 115.04,4 115.04,4.45 116.71,4.45 116.71,4.95 116.08,4.95 116.08,4.45 115.04,4.45 115.04,4.91 114.81,5.14 112.63,5.14 112.23,4.73 108.76,4.73 108.55,4.95 108.55,5.33 111.76,5.33 111.76,5.84 111.12,5.84 111.12,5.33 108.55,5.33 108.55,7.37 108.75,7.58 116.59,7.58
SGND on ART02 (solid shape): outline of 1137 points within 84.35,0.8 124.92,21.8
SGND on ART03 (solid shape): outline of 356 points within 83.93,24.89 91.75,40.13
SGND on GND04 (solid shape): outline of 6531 points within 14.58,0.54 219.18,40.79
SGND on ART05 (solid shape): outline of 977 points within 83.69,1.85 135.56,8.37
AC_L on BOTTOM (solid shape): outline of 154 points within 121.13,140.58 134.62,158.75
AC_L on ART02 (solid shape): outline of 971 points within 41.84,126.21 135.2,167.68
AC_L on ART03 (solid shape): outline of 1746 points within 110.97,97.06 158.43,159.11
AC_L on GND04 (solid shape): outline of 2169 points within 40.91,126.96 135.26,159.38
AC_L_SAMP on TOP (solid shape): 108.82,176.69 124.84,176.69 125.73,175.8 125.73,167 124.43,165.71 89.99,165.71 88.9,166.8 88.9,175.01 89.87,175.98 99.34,175.98 101.51,178.15 107.35,178.15
AC_L_SAMP on BOTTOM (solid shape): 124.21,178.44 124.21,171.7 122.81,170.31 89.53,170.31 88.9,170.94 88.9,178.69 89.53,179.32 123.32,179.32
AC_L_SAMP on ART03 (solid shape): outline of 123 points within 88.9,147.53 134.14,178.15
AC_L_SAMP on GND04 (solid shape): outline of 430 points within 88.9,147.8 140.02,178.15
AC_L_SAMP on ART05 (solid shape): 108.82,176.69 124.84,176.69 125.73,175.8 125.73,168.66 124.59,167.51 89.71,167.51 88.9,168.33 88.9,175.01 89.87,175.98 99.34,175.98 101.51,178.15 107.35,178.15
ACL1 on TOP (solid shape): 79.38,177.42 79.38,171.29 73.82,165.74 56.94,165.74 56.43,166.24 56.43,177.7 56.98,178.24 78.55,178.24
ACL1 on BOTTOM (solid shape): 71.1,176.89 78.71,176.89 79.38,176.23 79.38,171.52 76,168.14 76,168.11 75.92,168.03 57.06,168.03 56.43,168.66 56.43,176.21 57.12,176.89 64.5,176.89 65.97,178.37 69.63,178.37
ACL1 on ART03 (solid shape): 79.38,177.73 79.38,171.38 73.35,165.35 57.07,165.35 56.43,165.99 56.43,177.76 56.98,178.3 78.8,178.3
ACL1 on GND04 (solid shape): 79.38,177.92 79.38,171.54 73.18,165.35 57.07,165.35 56.43,165.99 56.43,177.56 57.26,178.38 78.92,178.38
ACL1 on ART05 (solid shape): 79.38,177.42 79.38,175.17 79.4,175.14 79.4,171.31 73.82,165.74 56.94,165.74 56.43,166.24 56.43,177.7 56.98,178.24 78.55,178.24
ACN1 on TOP (solid shape): 79.38,157.48 79.38,148.29 78.81,147.72 57.21,147.72 56.48,148.46 56.48,157.57 56.77,157.86 78.99,157.86
ACN1 on BOTTOM (solid shape): 79.38,157.48 79.38,148.38 78.77,147.77 57.11,147.77 56.49,148.39 56.49,157.59 56.77,157.86 78.99,157.86
ACN1 on ART03 (solid shape): 79.38,159.11 79.38,148.52 78.63,147.77 56.87,147.77 56.48,148.17 56.48,159.15 57.17,159.84 78.65,159.84
ACN1 on GND04 (solid shape): 79.38,159.11 79.38,146.86 78.78,146.26 57.12,146.26 56.48,146.91 56.48,159.15 57.17,159.84 78.65,159.84
CLAMPA on BOTTOM (solid shape): 183.71,129.63 183.71,126.88 182.25,125.42 182.25,123.03 181.68,122.45 180.68,122.45 180.1,121.87 177.05,121.87 176.89,122.03 176.89,124.1 177.06,124.26 178.77,124.26 180.58,126.07 180.58,129.79 180.84,130.05 183.29,130.05
CLAMPA on BOTTOM (solid shape): 163.58,130.56 163.58,129.29 163.32,129.03 161.29,129.03 160.85,128.6 160.85,127.56 158.62,125.32 158.62,124.28 156.17,121.83 154.37,121.83 154.03,122.17 154.03,124.14 154.23,124.33 155.8,124.33 157.21,125.73 157.21,125.74 157.44,125.96 157.44,130.57 157.8,130.94 163.19,130.94
CLAMPB on BOTTOM (solid shape): 120.41,130.67 120.41,129.21 120.16,128.96 118.22,128.96 117.67,128.42 117.67,127.33 115.44,125.09 115.44,122.65 114.93,122.13 111.06,122.13 110.85,122.34 110.85,124.29 111.08,124.51 112.39,124.51 113.74,125.86 114.31,125.86 114.42,125.97 114.42,130.72 114.74,131.04 120.04,131.04
CLAMPB on BOTTOM (solid shape): 140.53,130 140.53,126.88 138.84,125.18 137.49,125.18 137.07,124.77 137.07,123.06 136.79,122.78 135.84,122.78 134.91,121.85 133.81,121.85 133.71,121.94 133.71,124.29 133.94,124.51 135.15,124.51 136.56,125.92 137.57,125.92 137.64,125.99 137.64,126.3 137.64,126.3 137.64,129.83 137.99,130.18 140.36,130.18
CLAMPQ8 on TOP (solid shape): 17.68,51 17.68,47.29 19.36,45.61 21.03,45.61 21.24,45.4 21.24,43.13 21.07,42.96 16.39,42.96 14.61,44.74 14.61,50.86 15.06,51.3 17.38,51.3
CLAMPQ9 on TOP (solid shape): 58.95,51 58.95,47.29 60.63,45.61 62.31,45.61 62.51,45.4 62.51,43.13 62.34,42.96 59.92,42.96 55.89,46.99 55.89,50.86 56.33,51.3 58.66,51.3
CLAMPQ10 on TOP (solid shape): 103.35,50.97 103.35,47.25 105.02,45.58 106.7,45.58 106.91,45.37 106.91,43.1 106.74,42.93 102.06,42.93 100.28,44.71 100.28,50.82 100.72,51.27 103.05,51.27
CLAMPQ11 on TOP (solid shape): 144.21,50.92 144.21,47.75 146.52,45.44 147.95,45.44 148.24,45.16 148.24,43.13 148.07,42.96 143.39,42.96 141.61,44.74 141.61,50.86 142.06,51.3 143.83,51.3
CLAMPQ12 on TOP (solid shape): 39.27,51 39.27,47.29 40.95,45.61 42.62,45.61 42.83,45.4 42.83,43.13 42.66,42.96 37.98,42.96 36.2,44.74 36.2,50.86 36.65,51.3 38.97,51.3
CLAMPQ13 on TOP (solid shape): 80.09,51.02 80.09,47.65 82.16,45.58 83.26,45.58 83.41,45.42 83.41,43.14 83.2,42.93 79.2,42.93 77.42,44.71 77.42,50.82 77.86,51.27 79.84,51.27
CLAMPQ14 on TOP (solid shape): 124.36,51 124.36,47.29 126.04,45.61 127.71,45.61 127.92,45.4 127.92,43.13 127.75,42.96 123.07,42.96 121.29,44.74 121.29,50.86 121.74,51.3 124.06,51.3
CLAMPQ15 on TOP (solid shape): 165.38,51.04 165.38,47.54 167.31,45.61 168.99,45.61 169.19,45.4 169.19,43.13 169.02,42.96 164.35,42.96 162.57,44.74 162.57,50.86 163.01,51.3 165.12,51.3
DC_14V_INPUT on TOP (solid shape): 197.67,8.98 197.67,4.88 197.16,4.37 195.29,4.37 194.55,5.1 194.55,6.53 193.71,7.37 185.58,7.37 184.31,6.1 173.42,6.1 172.93,6.59 171.12,6.59 170.69,7.02 170.69,8.14 171.09,8.54 180.04,8.54 181.14,9.64 197.01,9.64
DRV_L_G on BOTTOM (solid shape): 178.49,28.06 178.49,25.46 178.22,25.18 176.42,25.18 175.45,24.21 173.95,24.21 173.85,24.31 173.85,24.32 173.07,25.1 171.42,25.1 170.99,25.53 172.85,25.53 172.85,26.29 172.09,26.29 172.09,25.53 170.99,25.53 170.61,25.91 168.76,25.91 168.43,26.24 168.43,27.05 172.85,27.05 172.85,27.81 172.09,27.81 172.09,27.05 168.43,27.05 168.43,27.15 168.68,27.41 170.79,27.41 171.6,28.22 173.41,28.22 173.69,28.5 178.05,28.5
DRVA_G on TOP (solid shape): 114.75,50.68 114.75,44.82 112.83,42.9 107.73,42.9 107.63,42.99 107.63,45.16 107.88,45.41 110.78,45.41 111.93,46.56 111.93,50.67 112.48,51.21 114.22,51.21
DRVA_G on BOTTOM (solid shape): 138.99,31.98 138.99,29.21 138.74,28.96 137.08,28.96 136.13,28.01 133.75,28.01 133.5,27.77 129.44,27.77 129.12,28.09 129.12,28.32 133.48,28.32 133.48,28.96 132.72,28.96 132.72,28.32 129.12,28.32 129.12,29.25 129.3,29.43 131.43,29.43 131.59,29.59 131.59,29.72 133.48,29.72 133.48,30.48 132.72,30.48 132.72,29.72 131.59,29.72 131.59,30.45 131.91,30.77 133.25,30.77 133.87,31.39 133.87,32.06 134.08,32.27 138.7,32.27
DRVA_G on ART03 (solid shape): 102.89,78.62 102.89,63.17 104.67,61.4 114.86,61.4 117.05,59.21 128.06,59.21 130.42,56.86 130.42,48.53 129.94,48.05 127.32,48.05 126.88,48.48 126.88,52.51 126.4,52.99 115.99,52.99 115.25,52.25 115.25,48.54 114.75,48.05 112.59,48.05 112.06,48.58 112.06,53.95 111.79,54.22 99.12,54.22 93.95,59.39 93.95,77.66 92.07,79.55 86.58,79.55 84.87,81.25 84.87,89.1 85.99,90.22 91.28,90.22
DRVA_G on GND04 (solid shape): outline of 362 points within 84.87,48.09 130.5,90.22
DRVA_G on ART05 (solid shape): 91.44,90.17 91.44,90.07 102.88,78.62 102.88,63.2 104.68,61.4 110.67,61.4 112.72,59.35 125.76,59.35 130.1,55.01 130.1,48.34 129.82,48.06 127.69,48.06 127.38,48.37 127.38,53.08 126.78,53.68 115.91,53.68 115.47,53.68 114.84,53.05 114.84,48.35 114.29,47.8 112.53,47.8 111.87,48.46 111.87,53.27 111.15,53.99 99.77,53.99 95.54,58.22 95.54,77.27 93.38,79.43 86.5,79.43 84.87,81.05 84.87,89.1 85.99,90.22 91.39,90.22
DRVC_G on TOP (solid shape): 156.09,50.71 156.09,47.51 151.51,42.93 149.21,42.93 148.97,43.18 148.97,45.19 149.21,45.44 150.76,45.44 152.62,47.3 152.62,50.78 153.09,51.25 155.55,51.25
DRVC_G on BOTTOM (solid shape): 158.07,30.1 158.07,27.92 158.07,27.91 158.07,27.25 157.87,27.05 155.44,27.05 155.12,26.73 152.19,26.73 151.82,26.36 149.95,26.36 149.32,26.99 147.86,26.99 147.85,26.99 147.66,26.99 147.39,27.26 147.39,28.93 147.67,29.2 149.59,29.2 149.95,28.85 151.71,28.85 153.25,30.39 157.78,30.39
DRVC_G on ART03 (solid shape): outline of 167 points within 114.93,47.98 171,74.3
EARTH on BOTTOM (solid shape): 18.39,158.87 18.39,154.39 17.95,153.95 7.22,153.95 6.94,154.23 6.94,158.57 7.55,159.18 18.08,159.18
EARTH on BOTTOM (solid shape): 107.44,166.88 107.44,163.19 107.19,162.94 107.18,162.94 107.07,162.83 83.42,162.83 81.5,160.91 65.91,160.91 65.9,160.92 58.78,160.92 58.52,161.19 58.52,164.44 58.92,164.85 78.93,164.85 81.47,167.39 106.93,167.39
EARTH on ART02 (solid shape): 5.97,178.69 5.97,159.64 6.48,159.13 17.91,159.13 18.29,158.75 18.29,153.8 18.8,153.29 28.32,153.29 28.57,153.54 28.57,163.58 29.72,164.72 60.07,164.72 60.8,163.99 60.8,159.24 60.18,158.62 36.45,158.62 34.8,156.97 34.8,150.88 33.53,149.61 2.67,149.61 1.02,151.26 1.02,178.82 1.52,179.32 5.33,179.32
IGND on TOP (solid shape): 192.59,6.41 192.59,2.74 192.1,2.24 171.23,2.24 170.67,2.8 170.67,5.35 171.16,5.84 172.21,5.84 172.83,5.23 185.3,5.23 187.04,6.97 192.03,6.97
IPFC on TOP (solid shape): 106.68,159 106.68,152.91 105.92,152.15 102.36,152.15 102.31,152.09 98.86,152.09 98.3,151.53 98.3,148.21 98.54,147.96 101.57,147.96 102.09,147.44 102.09,145.03 101.48,144.43 88.06,144.43 87.79,144.7 87.79,159.16 88.77,160.15 105.54,160.15
IPFC on BOTTOM (solid shape): 106.68,159 106.68,152.91 105.92,152.15 102.36,152.15 102.31,152.09 98.86,152.09 98.3,151.53 98.3,148.21 98.74,147.76 101.05,147.76 101.47,147.34 101.47,143.13 100.58,142.24 77.22,142.24 76.92,142.54 76.92,144.68 77.33,145.09 82.28,145.09 83.07,145.89 83.07,158.67 84.55,160.15 105.54,160.15
IPFC on ART03 (solid shape): 106.68,159 106.68,147.45 105.8,146.57 102.85,146.57 102.02,145.74 102.02,145.7 100.59,144.27 82.8,144.27 82.46,144.61 82.46,159.32 83.29,160.15 105.54,160.15
IPFC on GND04 (solid shape): 106.68,159 106.68,150.89 100.21,144.43 83.31,144.43 82.46,145.27 82.46,159.32 83.29,160.15 105.54,160.15
IPFC on ART05 (solid shape): 106.68,157.86 106.68,152.91 105.92,152.15 102.36,152.15 102.31,152.09 98.86,152.09 98.3,151.53 98.3,148.21 98.74,147.76 100.78,147.76 101.3,147.24 101.3,145.19 100.54,144.43 88.02,144.43 87.43,145.01 87.43,157.41 88.18,158.16 106.38,158.16
L on TOP (solid shape): 21.46,176.85 21.46,175.13 20.01,173.68 20.01,173.66 19.68,173.33 19.68,170.05 20.01,169.72 20.04,169.72 21.46,168.3 21.46,167.32 20.47,166.51 19.79,165.44 16.55,162.2 7.41,162.2 6.52,163.09 6.52,165.74 18.28,177.49 20.81,177.49
L on BOTTOM (solid shape): 21.62,176.59 21.62,175.54 19.56,173.48 19.56,172.98 19.55,172.97 19.46,172.09 19.55,171.2 19.56,171.19 19.56,170.42 19.68,170.3 19.68,170.06 20.13,169.61 20.15,169.61 21.53,168.22 21.53,167.16 16.58,162.2 7.81,162.2 6.52,163.49 6.52,165.74 18.28,177.49 18.97,177.49 19.01,177.53 20.68,177.53
L on ART03 (solid shape): 21.61,176.68 21.61,175.28 20.01,173.68 20.01,173.66 19.68,173.33 19.68,170.13 21.52,168.29 21.52,167.17 16.55,162.2 7.41,162.2 6.52,163.09 6.52,169.79 9.19,172.46 9.19,176.03 10.65,177.49 20.79,177.49
L on GND04 (solid shape): 21.66,176.59 21.66,175.32 19.68,173.33 19.68,170.17 21.47,168.38 21.47,167.12 16.55,162.2 7.41,162.2 6.52,163.09 6.52,169.79 9.19,172.46 9.19,176.03 10.65,177.49 20.76,177.49
L on ART05 (solid shape): 21.56,176.79 21.56,175.23 20.01,173.68 20.01,173.66 19.68,173.33 19.68,170.18 21.57,168.29 21.57,167.23 19.79,165.45 19.79,165.44 16.55,162.2 7.41,162.2 6.52,163.09 6.52,169.79 9.19,172.46 9.19,176.03 10.65,177.49 18.97,177.49 18.98,177.5 20.84,177.5
N on TOP (solid shape): 43.31,152.55 43.31,140.31 42.04,139.04 7.05,139.04 5.99,140.1 5.99,149.88 7.01,150.9 35.99,150.9 38.66,153.57 42.29,153.57
N on BOTTOM (solid shape): 53.13,153.22 53.13,151.34 52.66,150.88 43.81,150.88 43.31,150.37 43.31,139.93 42.42,139.04 7.01,139.04 6.12,139.93 6.12,150.02 7.01,150.9 35.99,150.9 38.66,153.57 52.78,153.57
N on ART03 (solid shape): 43.31,152.51 43.31,140.31 42.04,139.04 7.05,139.04 5.99,140.1 5.99,152.52 7.04,153.57 42.24,153.57
N on GND04 (solid shape): 43.31,153.08 43.31,140.69 41.66,139.04 7.05,139.04 5.99,140.1 5.99,152.52 7.04,153.57 42.81,153.57
N on ART05 (solid shape): 42.96,152.97 42.96,139.96 42.04,139.04 7.05,139.04 5.99,140.1 5.99,149.88 7.01,150.9 35.99,150.9 38.66,153.57 40.24,153.57 40.25,153.58 42.35,153.58
PCS+ on TOP (solid shape): outline of 83 points within 128.65,42.93 177.8,71.65
PCS+ on BOTTOM (solid shape): 176.58,71.29 176.58,46.02 176.15,45.59 174.24,45.59 173.97,45.86 173.97,54.39 173.26,55.1 171.24,55.1 171.24,55.11 139.63,55.11 136.16,51.64 136.16,48.93 135.32,48.08 133.52,48.08 132.97,48.63 132.97,52.89 135.93,55.84 135.93,69.99 137.65,71.71 176.16,71.71
PFC_G_A on BOTTOM (solid shape): 198.48,96.22 202.97,96.22 203.24,95.95 203.24,94.45 202.89,94.11 200.38,94.11 199.87,93.6 199.87,92.48 199.77,92.38 198.6,92.38 198.15,92.84 199.39,92.84 199.39,93.6 198.63,93.6 198.63,92.84 198.15,92.84 197.89,93.09 195.61,93.09 195.33,92.81 192.07,92.81 191.77,93.12 191.77,95 200.03,95 200.03,95.76 199.39,95.76 199.39,95 191.77,95 191.77,96.82 192.02,97.08 197.61,97.08
PFC_L on BOTTOM (solid shape): 148.97,129.67 148.97,125.86 150.45,124.38 153.2,124.38 153.34,124.25 153.34,122.11 153.05,121.83 149.35,121.83 148.91,122.27 148.91,123.49 148.7,123.7 145.86,123.7 145.52,124.05 145.52,129.67 146.03,130.18 148.46,130.18
PFC_L on BOTTOM (solid shape): 172.18,130.19 172.18,126.07 173.91,124.34 175.95,124.34 176.2,124.1 176.2,122.24 175.95,121.99 174.67,121.99 174.66,121.99 171.56,121.99 168.69,124.86 168.69,126.53 168.35,126.88 167.2,126.88 166.75,127.32 166.75,130.26 167.06,130.57 171.8,130.57
PFC_L on ART02 (solid shape): outline of 1141 points within 109.02,106.1 172.03,134.21
SPGND on TOP (solid shape): outline of 1035 points within 4.45,26.52 92.11,51.25
SPGND on BOTTOM (solid shape): 91.91,50.87 91.91,45.94 91.6,45.63 89.42,45.63 89.24,45.73 89.05,45.77 88.76,46.05 88.76,50.78 89.21,51.22 91.56,51.22
SPGND on BOTTOM (solid shape): 53.66,73.1 53.66,73.1 53.66,65.56 53.68,65.54 53.68,53.97 53.03,53.31 51.66,53.31 50.7,52.36 50.7,46.57 50.39,46.26 48.15,46.26 47.68,46.72 47.68,54.14 49.03,55.49 49.03,73.32 49.43,73.73 53.04,73.73
SPGND on BOTTOM (solid shape): 16.54,32.79 23.23,32.79 24.09,33.66 56.79,33.66 57.52,32.93 78.25,32.93 78.27,32.91 81.73,32.91 82.43,32.21 82.43,20.84 81.28,19.68 58.84,19.68 58.2,20.32 58.2,26.02 56.66,27.57 52.03,27.57 49.12,30.48 29.21,30.48 28.57,29.84 25.36,29.84 23.44,27.93 23.44,25.98 23.12,25.67 12.67,25.67 12.25,26.1 12.25,29.97 11.34,30.88 2.45,30.88 1.7,31.64 1.7,37.27 2.59,38.16 11.16,38.16
SPGND on ART02 (solid shape): outline of 2137 points within 25.6,19.72 91.31,52.22
SPGND on ART05 (solid shape): outline of 830 points within 0.92,0.72 76.89,40.94
SR_L_G on BOTTOM (solid shape): 119.17,17.98 119.17,15.06 118.77,14.65 116.57,14.65 116.24,14.98 113.85,14.98 113.18,14.31 111.56,14.31 111.01,14.86 113.03,14.86 113.03,15.49 112.39,15.49 112.39,14.86 111.01,14.86 110.9,14.96 109.17,14.96 108.92,15.21 108.92,16.38 113.03,16.38 113.03,17.02 112.39,17.02 112.39,16.38 108.92,16.38 108.92,16.39 109.17,16.63 111.15,16.63 112.01,17.5 113.12,17.5 113.93,18.31 118.84,18.31
SRA_G on TOP (solid shape): 29.09,50.71 29.09,44.86 27.16,42.93 22.06,42.93 21.97,43.02 21.97,45.19 22.21,45.44 25.11,45.44 25.14,45.47 25.53,45.47 26.38,46.32 26.38,50.82 26.81,51.25 28.55,51.25
SRA_G on BOTTOM (solid shape): 94.18,18.14 94.18,15.06 93.77,14.65 92.44,14.65 92.11,14.98 89.72,14.98 89.05,14.31 87.43,14.31 86.88,14.86 88.9,14.86 88.9,15.49 88.27,15.49 88.27,14.86 86.88,14.86 86.77,14.96 86.75,14.96 86.64,15.08 85.08,15.08 84.76,15.39 84.76,16.38 88.9,16.38 88.9,17.02 88.27,17.02 88.27,16.38 84.76,16.38 84.76,16.39 85.03,16.65 87.03,16.65 87.88,17.5 88.99,17.5 89.8,18.31 94.01,18.31
SRA_G on ART02 (solid shape): 56.52,86.2 56.52,78.95 53.94,76.38 47.3,76.38 45.12,74.2 45.12,48.69 44.55,48.12 42,48.12 41.53,48.59 41.53,53.05 40.63,53.95 35.98,53.95 35.97,53.93 31.97,53.93 31.08,53.04 31.08,48.64 30.51,48.08 27.17,48.08 26.37,48.88 26.37,50.01 26.35,50.04 26.35,52.75 30.75,57.15 30.75,57.15 38.73,65.14 38.73,86.36 40.01,87.63 55.09,87.63
SRA_G on GND04 (solid shape): 56.52,87 56.52,78.97 53.99,76.45 47.37,76.45 45.43,74.51 45.43,48.72 44.81,48.1 41.88,48.1 41.44,48.54 41.44,53.62 41.14,53.91 31.52,53.91 30.53,52.93 30.53,48.8 30.07,48.34 26.91,48.34 26.46,48.8 26.46,56.38 27.22,57.15 31.14,57.15 38.73,64.74 38.73,86.36 40.01,87.63 55.88,87.63
SRA_G on ART05 (solid shape): 56.52,87 56.52,79.12 54.99,77.59 48.7,77.59 44.8,73.69 44.8,48.45 44.41,48.07 42.47,48.07 42.09,48.45 42.09,53.18 41.27,54 31.57,54 30.48,52.91 30.48,48.85 29.65,48.02 27.13,48.02 26.4,48.76 26.4,56.21 27.34,57.15 31.75,57.15 38.73,64.14 38.73,86.36 40.01,87.63 55.88,87.63
SRC_G on TOP (solid shape): 70.36,50.71 70.36,44.86 68.44,42.93 63.33,42.93 63.24,43.02 63.24,45.19 63.49,45.44 66.39,45.44 67.54,46.6 67.54,50.7 68.09,51.25 69.83,51.25
SRC_G on BOTTOM (solid shape): 106.2,18.08 106.2,14.87 105.99,14.65 104.5,14.65 104.18,14.98 101.79,14.98 101.12,14.31 99.49,14.31 98.94,14.86 100.97,14.86 100.97,15.49 100.33,15.49 100.33,14.86 98.94,14.86 98.83,14.96 97.26,14.96 96.89,15.33 96.89,16.26 100.97,16.26 100.97,16.89 100.33,16.89 100.33,16.26 96.89,16.26 96.89,16.43 97.14,16.67 99.12,16.67 99.95,17.5 101.06,17.5 101.91,18.36 105.92,18.36
SRC_G on ART03 (solid shape): outline of 165 points within 20.53,48.02 85.95,71.71
VDCLOW+15V on BOTTOM (solid shape): 178.47,31.77 178.47,30.01 178.26,29.79 173.41,29.79 172.52,28.91 171.2,28.91 170.74,28.45 168.76,28.45 168.28,28.93 168.28,29.34 172.09,29.34 172.09,30.1 171.32,30.1 171.32,29.34 168.28,29.34 168.28,31.45 168.76,31.93 178.32,31.93
VLOW+15V on BOTTOM (solid shape): 211.58,78.94 211.58,74.68 211.28,74.37 206.15,74.37 205.77,74.75 205.77,75.74 205.66,75.84 200.38,75.84 200.03,76.2 200.03,76.33 204.34,76.33 204.34,76.96 203.84,76.96 203.84,76.33 200.03,76.33 200.03,78.49 200.71,79.17 211.35,79.17
VO+ on TOP (solid shape): 79.68,6.56 79.68,2.07 79.17,1.57 54.87,1.57 53.98,3.86 53.08,1.57 12.05,1.57 10.96,2.65 10.96,4.94 13.43,7.41 78.83,7.41
VO+ on BOTTOM (solid shape): 82.2,7.92 82.2,2.35 81.28,1.44 60.66,1.44 60.07,2.03 60.02,2.03 60.02,7.88 60.83,8.68 81.44,8.68
VO+ on BOTTOM (solid shape): 60.76,72.99 60.76,57.77 64.53,54 64.53,48.5 63.84,47.82 62.23,47.82 61.62,48.44 61.62,52 61.65,52.03 61.65,52.34 60.42,53.57 57.4,53.57 56.85,54.12 56.85,72.99 57.52,73.65 60.1,73.65
VO+ on ART02 (solid shape): 78.99,6.48 78.99,2.16 78.49,1.65 54.95,1.65 53.98,3.86 53,1.65 12.19,1.65 11.43,2.41 11.43,5.08 13.84,7.49 77.98,7.49
VO+ on ART03 (solid shape): outline of 3375 points within 9.71,0.86 82.92,51.51
VP+5V on TOP (solid shape): 207.99,13.19 207.99,10.91 207.51,10.43 194.68,10.43 194.46,10.65 194.46,13.2 194.76,13.5 207.68,13.5
VP+5V on BOTTOM (solid shape): 207.39,39.06 209.01,39.06 209.09,38.99 209.09,38.55 208.99,38.45 207.42,38.45 206.93,37.96 203.83,37.96 203.69,38.1 203.69,39.82 203.91,40.04 206.41,40.04
VP+15V on BOTTOM (solid shape): 213.69,65.99 213.69,59.66 213.46,59.44 210.44,59.44 210.19,59.69 210.19,61.75 209.85,62.08 209.85,62.87 211.07,62.87 211.07,63.5 210.44,63.5 210.44,62.87 209.85,62.87 209.85,63.5 210.29,63.93 210.29,65.94 210.72,66.37 213.31,66.37
VP+15V on BOTTOM (solid shape): 213.11,85.6 214.63,85.6 215.01,85.22 215.01,83.82 214.38,83.19 212.08,83.19 210.44,81.55 207.96,81.55 207.52,81.99 207.52,83.69 207.39,83.82 207.39,84.45 208.53,84.45 208.53,85.09 207.9,85.09 207.9,84.45 207.39,84.45 207.39,85.09 207.77,85.47 207.77,87.48 208.16,87.87 210.83,87.87
VP+15V on BOTTOM (solid shape): 166.93,18.11 166.93,11.74 167.63,11.04 177.56,11.04 178.25,11.72 178.25,13.05 179.7,13.05 179.7,13.83 178.88,13.83 178.88,13.05 178.25,13.05 178.25,15.19 178.17,15.27 179.25,15.27 179.25,15.86 178.66,15.86 178.66,15.27 178.17,15.27 178.11,15.33 178.11,16.46 178.45,16.8 178.45,19.24 178.79,19.58 180.22,19.58 180.5,19.3 180.5,10.89 179.23,9.62 168.03,9.62 167.3,8.88 167.3,7.3 166.91,6.91 165.85,6.91 165.37,7.39 165.37,8.34 163.79,9.92 157.57,9.92 156.74,10.75 156.74,14.23 158.11,14.23 158.11,15.14 157.22,15.14 157.22,14.23 156.74,14.23 156.74,15.91 156.52,16.13 156.52,16.25 157.88,16.25 157.88,17.16 156.99,17.16 156.99,16.25 156.52,16.25 156.52,16.53 156.52,16.53 156.52,17.63 156.85,17.96 158.59,17.96 158.59,18.87 157.7,18.87 157.7,17.96 156.85,17.96 156.92,18.02 156.92,19.4 157.18,19.66 165.38,19.66
VP+15V_DCDCA on BOTTOM (solid shape): 138.82,35.17 138.82,34 138.55,33.73 133.96,33.73 133.3,33.07 133.3,31.67 133.05,31.42 131.59,31.42 130.58,30.41 129.56,30.41 128.97,31 128.97,32 132.72,32 132.72,32.77 131.95,32.77 131.95,32 128.97,32 128.97,32.38 129.69,33.11 131.01,33.11 132.16,34.26 132.16,34.29 133.28,35.41 138.58,35.41
VP+15V_DCDCB on BOTTOM (solid shape): 158.1,33.11 158.1,32.11 157.83,31.83 153.35,31.83 151.88,30.37 151.88,29.84 151.55,29.51 150.38,29.51 150.11,29.77 147.62,29.77 147.39,30 147.39,31.13 147.72,31.46 151.77,31.46 153.63,33.32 157.89,33.32
VP+15V_HF_PFC on BOTTOM (solid shape): 202.44,98.17 202.44,97.34 201.93,96.84 198.76,96.84 198.53,97.07 198.53,97.28 200.03,97.28 200.03,98.04 199.39,98.04 199.39,97.28 198.53,97.28 198.53,98.09 198.15,98.47 191.78,98.47 191.55,98.7 191.54,98.7 191.54,99.62 191.77,99.85 200.76,99.85
VP-5V on BOTTOM (solid shape): 209.08,37.87 209.08,37.33 209.33,37.07 211.2,37.07 211.46,36.82 211.46,35.5 211.2,35.24 207.96,35.24 207.77,35.43 207.77,37.91 207.9,38.04 208.91,38.04
VPFC on TOP (solid shape): 154.05,142.32 154.15,142.24 154.08,142.13 154.94,137.24 155.8,142.13 155.73,142.24 155.83,142.32 172.46,142.32 172.56,142.24 172.5,142.13 173.35,137.24 174.21,142.13 174.15,142.24 174.25,142.32 190.88,142.32 191.52,137.37 192.15,142.32 194.4,142.32 195.16,141.56 195.16,134.54 194.29,133.67 178.69,133.67 177.88,132.87 177.88,127.15 177.15,126.42 175.28,126.42 175.02,126.67 175.02,132.57 174.07,133.53 156.18,133.53 154.64,131.99 154.64,127.63 153.94,126.93 152.44,126.93 151.71,127.66 151.71,130.7 151.69,130.72 151.69,131.73 150.35,133.07 145.13,133.07 144.43,133.77 144.43,137.57 149.18,142.32
VPFC on BOTTOM (solid shape): 185.96,50.33 185.96,48.32 182.83,45.19 181.4,45.19 181.16,45.44 181.16,48.94 182.68,50.47 185.83,50.47
VPFC on BOTTOM (solid shape): 91.88,129.98 91.88,127.47 91.63,127.22 91.63,124.78 91.44,124.59 91.44,124.56 90.22,124.56 90.02,124.76 90.02,126.82 89.36,127.48 89.36,129.9 89.79,130.33 91.54,130.33
VPFC on BOTTOM (solid shape): 208.39,151.25 208.39,124.46 208.4,124.45 208.4,111.85 207.82,111.28 206.25,111.28 205.49,112.04 205.49,114.68 206.76,115.95 206.76,128.91 205.49,130.18 205.49,150.91 206.25,151.67 207.96,151.67
VPFC on BOTTOM (solid shape): outline of 308 points within 151.78,127.16 194.01,142.64
VPFC on ART02 (solid shape): outline of 7325 points within 49.65,31.53 208.63,169.04
VPFC on ART03 (solid shape): outline of 2677 points within 148.23,107.41 211.69,178.18
VPFC_LF+15V on TOP (solid shape): 76.77,142.1 76.77,139.15 77.75,138.17 77.75,136.91 78.17,136.49 78.17,134.66 77.84,134.33 72.01,134.33 71.64,134.7 71.64,137.16 77.34,137.16 77.34,137.67 76.71,137.67 76.71,137.16 71.64,137.16 71.64,142.09 72.16,142.61 76.26,142.61
VPFC_LF+15V on BOTTOM (solid shape): 73.91,141.4 73.91,133.47 73.79,133.34 72.56,133.34 72.39,133.5 72.39,138.95 72.07,139.28 72.07,140.58 71.68,140.97 71.68,142.35 71.97,142.64 72.67,142.64
VS+5V on TOP (solid shape): 131.56,7.65 131.56,4.56 131.32,4.32 129.92,4.32 129.58,4.66 129.58,6.13 129.25,6.46 120.45,6.46 120.28,6.63 120.28,7.72 120.43,7.87 131.34,7.87
VS+15V on TOP (solid shape): 129.67,2.01 131.34,2.01 131.48,1.87 131.48,0.82 131.29,0.63 127.37,0.63 127.06,0.94 127.06,2.65 129.03,2.65
VS+15V on BOTTOM (solid shape): 131.24,2.84 131.24,0.93 130.95,0.63 127.02,0.63 126.67,0.98 126.67,2.84 126.93,3.1 130.99,3.1
VS+15V on BOTTOM (solid shape): 107.96,7.36 107.96,1.26 107.74,1.05 106.2,1.05 105.94,1.31 105.94,3.62 105.72,3.83 105.72,5.1 106.12,5.5 106.12,7.25 106.34,7.48 107.84,7.48
VS+15V on BOTTOM (solid shape): 95.89,7.36 95.89,1.26 95.68,1.05 94.13,1.05 93.87,1.31 93.87,3.62 93.66,3.83 93.66,4.45 94.87,4.45 94.87,5.08 94.23,5.08 94.23,4.45 93.66,4.45 93.66,5.1 94.05,5.5 94.05,7.25 94.28,7.48 95.78,7.48
VS+15V on BOTTOM (solid shape): 120.08,7.18 120.08,1.55 119.86,1.34 118.32,1.34 118.06,1.6 118.06,3.88 118.89,3.88 118.89,4.42 118.29,4.42 118.29,3.88 118.06,3.88 118.06,3.91 117.84,4.12 117.84,5.06 118.24,5.45 118.24,7.24 118.47,7.48 119.78,7.48
VS+15V on ART03 (solid shape): outline of 368 points within 93.6,0.73 129.44,6.32
VS+15V_DCDCA on BOTTOM (solid shape): 94.16,21.14 94.16,20.05 93.84,19.73 89.41,19.73 88.85,19.18 88.85,18.34 88.6,18.08 87.14,18.08 86.72,17.66 85.03,17.66 84.78,17.91 84.78,18.54 88.27,18.54 88.27,19.3 87.63,19.3 87.63,18.54 84.78,18.54 84.78,20.86 85.29,21.38 93.92,21.38
VS+15V_DCDCB on BOTTOM (solid shape): 106.18,20.92 106.18,20.03 105.91,19.76 101.32,19.76 100.91,19.36 100.91,18.34 100.66,18.08 99.21,18.08 98.79,17.67 97.17,17.67 96.87,17.96 96.87,18.67 100.33,18.67 100.33,19.3 99.69,19.3 99.69,18.67 96.87,18.67 96.87,20.85 97.35,21.33 105.77,21.33
VSLOW+15V on BOTTOM (solid shape): 119.08,20.89 119.08,20.06 118.79,19.77 113.4,19.77 112.98,19.35 112.98,18.34 112.73,18.08 111.27,18.08 110.85,17.67 109.31,17.67 109.02,17.96 109.02,18.67 112.39,18.67 112.39,19.3 111.76,19.3 111.76,18.67 109.02,18.67 109.02,20.86 109.37,21.21 118.75,21.21
N15409465 on TOP (solid shape): 43.94,176.4 43.94,157.96 42.93,156.94 37.56,156.94 35.56,154.94 23.37,154.94 22.1,156.21 22.1,164.15 24,166.05 24,166.15 24.17,166.33 24.17,169.43 23.49,170.12 23.47,170.12 22.22,171.37 22.22,172.28 22.55,172.61 22.55,172.63 24,174.08 24,174.68 26.52,177.2 43.14,177.2
N15409465 on BOTTOM (solid shape): 43.81,176.36 43.81,168.78 44.7,167.89 52.98,167.89 53.36,167.51 53.36,165.66 52.82,165.13 41.48,165.13 36.96,160.6 36.96,156.34 35.56,154.94 23,154.94 21.69,156.25 21.69,157.67 22.1,158.08 22.1,164.34 24.22,166.46 24.22,169.35 22.01,171.56 22.01,172.7 26.56,177.25 42.93,177.25
N15409465 on ART03 (solid shape): 43.81,176.53 43.81,155.7 43.05,154.94 23.37,154.94 23.36,154.95 22.97,154.95 21.68,156.24 21.68,157.79 22.1,158.2 22.1,164.35 23.5,165.75 23.59,165.75 24.17,166.33 24.17,169.43 23.49,170.12 23.47,170.12 22.07,171.51 22.07,172.76 26.52,177.2 43.14,177.2
N15409465 on GND04 (solid shape): 43.94,176.4 43.94,155.83 43.05,154.94 23.05,154.94 21.71,156.28 21.71,157.33 22.01,157.64 22.01,164.17 24.17,166.33 24.17,169.43 22.02,171.58 22.02,172.71 26.52,177.2 43.14,177.2
N15409465 on ART05 (solid shape): 43.94,176.4 43.94,157.96 42.93,156.94 37.56,156.94 35.56,154.94 22.84,154.94 21.68,156.1 21.68,157.77 22.1,158.19 22.1,158.2 22.1,162.5 22.09,162.51 22.09,164.41 24.17,166.49 24.17,169.43 22.07,171.54 22.07,172.76 26.52,177.2 43.14,177.2
N15414859 on BOTTOM (solid shape): 138.2,161.07 138.2,156.98 137.56,156.33 134.87,156.33 131.55,159.65 129.05,159.65 128.88,159.83 128.88,160.81 128.99,160.93 135.79,160.93 136.52,161.66 137.62,161.66
N15414880 on BOTTOM (solid shape): 138.18,170.85 138.18,169.93 136.31,168.05 131.6,168.05 130.62,169.04 128.36,169.04 128.04,169.36 128.04,171.28 128.32,171.57 137.46,171.57
N15816850 on BOTTOM (solid shape): 53.54,158.47 53.54,155.48 53.1,155.04 47.4,155.04 47.04,155.4 47.04,158.42 47.35,158.72 53.29,158.72
N15816858 on BOTTOM (solid shape): 53.5,163.56 53.5,160.28 53.35,160.12 47.4,160.12 47.04,160.48 47.04,163.5 47.35,163.8 53.26,163.8
N16123691 on TOP (solid shape): 15.62,19.16 15.62,11.55 10.95,6.87 9.96,6.87 7.48,9.35 7.48,19.36 7.99,19.87 14.92,19.87
N16123691 on BOTTOM (solid shape): 23.44,22.14 23.44,17.45 22.93,16.94 14.45,16.94 12.37,14.87 12.37,8.16 11.17,6.96 10.17,6.96 7.77,9.36 1.44,15.68 1.44,22.07 2.08,22.7 22.87,22.7
N16123691 on ART03 (solid shape): 15.62,19.16 15.62,11.55 10.95,6.87 9.96,6.87 7.48,9.35 7.48,19.36 7.99,19.87 14.92,19.87
N16123691 on GND04 (solid shape): 15.62,19.16 15.62,11.55 10.95,6.87 9.96,6.87 7.48,9.35 7.48,19.36 7.99,19.87 14.92,19.87
N16148380 on TOP (solid shape): 48.1,24.8 48.1,12.88 46.67,11.46 27.47,11.46 25.9,13.02 25.9,24.63 26.79,25.52 47.38,25.52
N16599678 on BOTTOM (solid shape): 97.84,129.98 97.84,123.87 97.4,123.43 95.65,123.43 95.33,123.11 95.33,120.19 95.15,120.01 94.5,120.01 94.38,120.13 94.38,124.92 94.74,125.29 94.74,129.91 95.12,130.28 97.54,130.28
N16600162 on BOTTOM (solid shape): 74.22,130.12 74.22,123.75 73.69,123.22 72.24,123.22 71.68,122.66 71.68,120.87 71.41,120.59 70.56,120.59 70.22,120.93 70.22,124.44 71.55,125.78 71.55,130.38 71.88,130.71 73.63,130.71
N17243036 on BOTTOM (solid shape): 135.51,167.21 135.51,161.87 135.28,161.65 133.35,161.65 133.12,161.87 133.12,162.56 134.11,162.56 134.11,163.19 133.48,163.19 133.48,162.56 133.12,162.56 133.12,163.83 135,163.83 135,164.47 134.37,164.47 134.37,163.83 134.24,163.83 134.24,164.47 133.6,164.47 133.6,163.83 133.12,163.83 133.12,165.61 134.11,165.61 134.11,166.62 133.6,166.62 133.6,165.61 133.12,165.61 133.12,167.17 133.3,167.35 135.37,167.35
N17277038 on TOP (solid shape): outline of 151 points within 11.62,58.67 36.7,87.25
N17277038 on BOTTOM (solid shape): outline of 151 points within 11.62,58.98 36.7,87.55
N17277038 on ART02 (solid shape): outline of 131 points within 11.68,58.98 36.7,87.55
N17277038 on GND04 (solid shape): outline of 131 points within 11.68,58.67 36.7,87.25
N17277038 on ART05 (solid shape): outline of 131 points within 11.68,58.98 36.7,87.55
N17381567 on BOTTOM (solid shape): 186.81,125.02 186.81,119.97 186.41,119.56 183.97,119.56 183.67,119.86 183.67,124.91 184.05,125.29 186.55,125.29
N17381622 on BOTTOM (solid shape): 140.34,124.45 140.34,120.46 140.05,120.17 138.86,120.17 138.59,120.44 138.59,124.52 138.71,124.64 140.15,124.64
N17452823 on BOTTOM (solid shape): 205.33,74.88 205.33,72.87 205.16,72.69 203.5,72.69 203.28,72.92 200.33,72.92 200.1,73.15 200.1,73.28 204.47,73.28 204.47,74.55 203.84,74.55 203.84,73.28 200.1,73.28 200.1,74.96 200.36,75.21 205,75.21
N17452839 on BOTTOM (solid shape): 204.83,62.18 206.47,62.18 206.48,62.2 206.53,62.2 207,61.72 208.81,61.72 209.02,61.51 209.02,59.57 208.75,59.31 200.37,59.31 200.04,59.63 200.04,61.34 203.84,61.34 203.84,61.98 203.07,61.98 203.07,61.34 200.04,61.34 200.04,62.15 200.47,62.59 204.42,62.59
N17452887 on BOTTOM (solid shape): 57.91,142.6 57.91,141.49 56.8,140.38 56.8,139.3 56.56,139.05 55.92,139.05 55.79,138.92 55.79,137.08 55.35,136.64 54.48,136.64 54.17,136.33 54.17,135.28 54.04,135.15 52.2,135.15 52,135.36 52,139.7 56.39,139.7 56.39,140.46 55.5,140.46 55.5,139.7 52,139.7 52,142.36 52.59,142.95 57.56,142.95
N17453218 on BOTTOM (solid shape): 199.79,83.34 206.17,83.34 206.47,83.04 206.47,80.53 206.19,80.25 195.06,80.25 194.86,80.45 194.86,82.42 199.39,82.42 199.39,83.06 198.75,83.06 198.75,82.42 194.86,82.42 194.86,82.83 195.21,83.19 197.6,83.19 197.9,83.49 199.64,83.49
N17453412 on BOTTOM (solid shape): 100.71,3.74 102.37,3.74 102.72,3.39 104.67,3.39 104.91,3.15 104.91,1.54 104.65,1.28 96.83,1.28 96.6,1.5 96.6,3.05 99.69,3.05 99.69,3.68 99.06,3.68 99.06,3.05 96.6,3.05 96.6,3.88 96.86,4.15 100.31,4.15
N17453587 on BOTTOM (solid shape): 88.65,3.74 90.31,3.74 90.66,3.39 92.6,3.39 92.84,3.15 92.84,1.54 92.58,1.28 85.11,1.28 84.81,1.57 84.81,3.05 87.63,3.05 87.63,3.68 87,3.68 87,3.05 84.81,3.05 84.81,3.92 85.04,4.15 88.24,4.15
N17453815 on BOTTOM (solid shape): 112.78,3.74 114.44,3.74 114.79,3.39 116.73,3.39 116.97,3.15 116.97,1.54 116.71,1.28 108.89,1.28 108.66,1.5 108.66,2.92 111.76,2.92 111.76,3.68 111.12,3.68 111.12,2.92 108.66,2.92 108.66,3.88 108.93,4.15 112.37,4.15
N17454032 on BOTTOM (solid shape): 173.11,14.52 177.02,14.52 177.22,14.32 177.22,12.84 176.94,12.56 168.7,12.56 168.4,12.86 168.4,14.67 168.66,14.93 172.71,14.93
N17454238 on BOTTOM (solid shape): 133.1,17.07 134.76,17.07 135.11,16.73 137.05,16.73 137.29,16.49 137.29,15.44 137.29,15.44 137.29,15.26 136.94,14.91 129.33,14.91 128.98,15.26 128.98,16.38 132.08,16.38 132.08,17.02 131.44,17.02 131.44,16.38 128.98,16.38 128.98,16.42 129.25,16.68 130.56,16.68 131.35,17.47 131.35,17.48 132.69,17.48
N17454469 on BOTTOM (solid shape): 151.51,16.44 153.17,16.44 153.52,16.09 155.47,16.09 155.71,15.85 155.71,14.77 155.34,14.4 147.72,14.4 147.4,14.71 147.4,15.62 150.5,15.62 150.5,16.38 149.86,16.38 149.86,15.62 147.4,15.62 147.4,15.8 147.64,16.04 148.91,16.04 149.26,16.39 149.26,16.39 149.72,16.85 151.11,16.85
N17603041 on TOP (solid shape): 130.47,82.29 130.47,66.32 129.76,65.61 125.71,65.61 125.16,66.16 125.16,69.71 124.39,70.48 113.62,70.48 112.29,69.15 112.29,66.42 111.44,65.58 106.48,65.58 106.03,66.03 106.03,75.09 107.01,76.07 117.94,76.07 120.31,78.44 120.31,84.44 121.55,85.68 127.08,85.68
N17603041 on BOTTOM (solid shape): 132.05,80.95 132.05,66.11 130.68,64.74 126.26,64.74 125.16,65.83 125.16,69.1 123.69,70.58 113.55,70.58 112.29,69.31 112.29,65.89 111.48,65.08 106.95,65.08 106.03,66 106.03,75.57 106.84,76.37 117.94,76.37 120.31,78.74 120.31,84 121.84,85.52 127.48,85.52
N17603041 on GND04 (solid shape): 132.05,80.88 132.05,66.09 131.09,65.12 125.9,65.12 125.16,65.86 125.16,69.16 123.75,70.57 113.6,70.57 112.29,69.25 112.29,65.89 111.74,65.34 106.73,65.34 106.03,66.04 106.03,75.4 107.01,76.37 117.94,76.37 120.31,78.74 120.31,84.18 121.56,85.43 127.51,85.43
